v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {FB_DIV   (auto · no-stub)} -300 -680 0 0 0.4 0.4 {layer=4}
C {sky130_fd_pr/nfet_01v8.sym} 0 0 0 0 {name=Xd5_g0N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 20 -30 20 -76 {}
N -20 0 -66 0 {}
N 20 30 20 76 {}
N 20 0 66 0 {}
T {Xd5_g0N0} -16 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 202 0 0 0 {name=Xd5_g0N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 222 -30 222 -76 {}
N 182 0 136 0 {}
N 222 30 222 76 {}
N 222 0 268 0 {}
T {Xd5_g0N1} 186 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 404 0 0 0 {name=Xd5_g0N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 424 -30 424 -76 {}
N 384 0 338 0 {}
N 424 30 424 76 {}
N 424 0 470 0 {}
T {Xd5_g0N2} 388 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 606 0 0 0 {name=Xd5_g0P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 626 30 626 76 {}
N 586 0 540 0 {}
N 626 -30 626 -76 {}
N 626 0 672 0 {}
T {Xd5_g0P0} 590 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 808 0 0 0 {name=Xd5_g0P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 828 30 828 76 {}
N 788 0 742 0 {}
N 828 -30 828 -76 {}
N 828 0 874 0 {}
T {Xd5_g0P1} 792 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 1010 0 0 0 {name=Xd5_g0P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 1030 30 1030 76 {}
N 990 0 944 0 {}
N 1030 -30 1030 -76 {}
N 1030 0 1076 0 {}
T {Xd5_g0P2} 994 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1212 0 0 0 {name=Xd5_i0N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1232 -30 1232 -76 {}
N 1192 0 1146 0 {}
N 1232 30 1232 76 {}
N 1232 0 1278 0 {}
T {Xd5_i0N} 1196 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 1414 0 0 0 {name=Xd5_i0P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 1434 30 1434 76 {}
N 1394 0 1348 0 {}
N 1434 -30 1434 -76 {}
N 1434 0 1480 0 {}
T {Xd5_i0P} 1398 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1616 0 0 0 {name=Xd5_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1636 -30 1636 -76 {}
N 1596 0 1550 0 {}
N 1636 30 1636 76 {}
N 1636 0 1682 0 {}
T {Xd5_g2N0} 1600 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1818 0 0 0 {name=Xd5_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1838 -30 1838 -76 {}
N 1798 0 1752 0 {}
N 1838 30 1838 76 {}
N 1838 0 1884 0 {}
T {Xd5_g2N1} 1802 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 2020 0 0 0 {name=Xd5_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 2040 -30 2040 -76 {}
N 2000 0 1954 0 {}
N 2040 30 2040 76 {}
N 2040 0 2086 0 {}
T {Xd5_g2N2} 2004 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2222 0 0 0 {name=Xd5_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2242 30 2242 76 {}
N 2202 0 2156 0 {}
N 2242 -30 2242 -76 {}
N 2242 0 2288 0 {}
T {Xd5_g2P0} 2206 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2424 0 0 0 {name=Xd5_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2444 30 2444 76 {}
N 2404 0 2358 0 {}
N 2444 -30 2444 -76 {}
N 2444 0 2490 0 {}
T {Xd5_g2P1} 2408 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2626 0 0 0 {name=Xd5_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2646 30 2646 76 {}
N 2606 0 2560 0 {}
N 2646 -30 2646 -76 {}
N 2646 0 2692 0 {}
T {Xd5_g2P2} 2610 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 2828 0 0 0 {name=Xd5_i2N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 2848 -30 2848 -76 {}
N 2808 0 2762 0 {}
N 2848 30 2848 76 {}
N 2848 0 2894 0 {}
T {Xd5_i2N} 2812 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3030 0 0 0 {name=Xd5_i2P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3050 30 3050 76 {}
N 3010 0 2964 0 {}
N 3050 -30 3050 -76 {}
N 3050 0 3096 0 {}
T {Xd5_i2P} 3014 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 3232 0 0 0 {name=Xd5_x1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 3252 -30 3252 -76 {}
N 3212 0 3166 0 {}
N 3252 30 3252 76 {}
N 3252 0 3298 0 {}
T {Xd5_x1N0} 3216 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 3434 0 0 0 {name=Xd5_x1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 3454 -30 3454 -76 {}
N 3414 0 3368 0 {}
N 3454 30 3454 76 {}
N 3454 0 3500 0 {}
T {Xd5_x1N1} 3418 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 3636 0 0 0 {name=Xd5_x1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 3656 -30 3656 -76 {}
N 3616 0 3570 0 {}
N 3656 30 3656 76 {}
N 3656 0 3702 0 {}
T {Xd5_x1N2} 3620 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3838 0 0 0 {name=Xd5_x1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3858 30 3858 76 {}
N 3818 0 3772 0 {}
N 3858 -30 3858 -76 {}
N 3858 0 3904 0 {}
T {Xd5_x1P0} 3822 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 4040 0 0 0 {name=Xd5_x1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 4060 30 4060 76 {}
N 4020 0 3974 0 {}
N 4060 -30 4060 -76 {}
N 4060 0 4106 0 {}
T {Xd5_x1P1} 4024 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 4242 0 0 0 {name=Xd5_x1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 4262 30 4262 76 {}
N 4222 0 4176 0 {}
N 4262 -30 4262 -76 {}
N 4262 0 4308 0 {}
T {Xd5_x1P2} 4226 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4444 0 0 0 {name=Xd5_x2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4464 -30 4464 -76 {}
N 4424 0 4378 0 {}
N 4464 30 4464 76 {}
N 4464 0 4510 0 {}
T {Xd5_x2N0} 4428 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4646 0 0 0 {name=Xd5_x2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4666 -30 4666 -76 {}
N 4626 0 4580 0 {}
N 4666 30 4666 76 {}
N 4666 0 4712 0 {}
T {Xd5_x2N1} 4630 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4848 0 0 0 {name=Xd5_x2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4868 -30 4868 -76 {}
N 4828 0 4782 0 {}
N 4868 30 4868 76 {}
N 4868 0 4914 0 {}
T {Xd5_x2N2} 4832 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5050 0 0 0 {name=Xd5_x2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5070 30 5070 76 {}
N 5030 0 4984 0 {}
N 5070 -30 5070 -76 {}
N 5070 0 5116 0 {}
T {Xd5_x2P0} 5034 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5252 0 0 0 {name=Xd5_x2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5272 30 5272 76 {}
N 5232 0 5186 0 {}
N 5272 -30 5272 -76 {}
N 5272 0 5318 0 {}
T {Xd5_x2P1} 5236 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5454 0 0 0 {name=Xd5_x2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5474 30 5474 76 {}
N 5434 0 5388 0 {}
N 5474 -30 5474 -76 {}
N 5474 0 5520 0 {}
T {Xd5_x2P2} 5438 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 5656 0 0 0 {name=Xd5_x3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 5676 -30 5676 -76 {}
N 5636 0 5590 0 {}
N 5676 30 5676 76 {}
N 5676 0 5722 0 {}
T {Xd5_x3N0} 5640 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 5858 0 0 0 {name=Xd5_x3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 5878 -30 5878 -76 {}
N 5838 0 5792 0 {}
N 5878 30 5878 76 {}
N 5878 0 5924 0 {}
T {Xd5_x3N1} 5842 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6060 0 0 0 {name=Xd5_x3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6080 -30 6080 -76 {}
N 6040 0 5994 0 {}
N 6080 30 6080 76 {}
N 6080 0 6126 0 {}
T {Xd5_x3N2} 6044 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 6262 0 0 0 {name=Xd5_x3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 6282 30 6282 76 {}
N 6242 0 6196 0 {}
N 6282 -30 6282 -76 {}
N 6282 0 6328 0 {}
T {Xd5_x3P0} 6246 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 6464 0 0 0 {name=Xd5_x3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 6484 30 6484 76 {}
N 6444 0 6398 0 {}
N 6484 -30 6484 -76 {}
N 6484 0 6530 0 {}
T {Xd5_x3P1} 6448 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 6666 0 0 0 {name=Xd5_x3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 6686 30 6686 76 {}
N 6646 0 6600 0 {}
N 6686 -30 6686 -76 {}
N 6686 0 6732 0 {}
T {Xd5_x3P2} 6650 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6868 0 0 0 {name=Xd5_x4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6888 -30 6888 -76 {}
N 6848 0 6802 0 {}
N 6888 30 6888 76 {}
N 6888 0 6934 0 {}
T {Xd5_x4N0} 6852 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 7070 0 0 0 {name=Xd5_x4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 7090 -30 7090 -76 {}
N 7050 0 7004 0 {}
N 7090 30 7090 76 {}
N 7090 0 7136 0 {}
T {Xd5_x4N1} 7054 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 7272 0 0 0 {name=Xd5_x4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 7292 -30 7292 -76 {}
N 7252 0 7206 0 {}
N 7292 30 7292 76 {}
N 7292 0 7338 0 {}
T {Xd5_x4N2} 7256 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7474 0 0 0 {name=Xd5_x4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7494 30 7494 76 {}
N 7454 0 7408 0 {}
N 7494 -30 7494 -76 {}
N 7494 0 7540 0 {}
T {Xd5_x4P0} 7458 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7676 0 0 0 {name=Xd5_x4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7696 30 7696 76 {}
N 7656 0 7610 0 {}
N 7696 -30 7696 -76 {}
N 7696 0 7742 0 {}
T {Xd5_x4P1} 7660 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7878 0 0 0 {name=Xd5_x4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7898 30 7898 76 {}
N 7858 0 7812 0 {}
N 7898 -30 7898 -76 {}
N 7898 0 7944 0 {}
T {Xd5_x4P2} 7862 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8080 0 0 0 {name=Xd5_d0_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8100 -30 8100 -76 {}
N 8060 0 8014 0 {}
N 8100 30 8100 76 {}
N 8100 0 8146 0 {}
T {Xd5_d0_g1N0} 8064 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8282 0 0 0 {name=Xd5_d0_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8302 -30 8302 -76 {}
N 8262 0 8216 0 {}
N 8302 30 8302 76 {}
N 8302 0 8348 0 {}
T {Xd5_d0_g1N1} 8266 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8484 0 0 0 {name=Xd5_d0_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8504 -30 8504 -76 {}
N 8464 0 8418 0 {}
N 8504 30 8504 76 {}
N 8504 0 8550 0 {}
T {Xd5_d0_g1N2} 8468 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 8686 0 0 0 {name=Xd5_d0_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 8706 30 8706 76 {}
N 8666 0 8620 0 {}
N 8706 -30 8706 -76 {}
N 8706 0 8752 0 {}
T {Xd5_d0_g1P0} 8670 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 8888 0 0 0 {name=Xd5_d0_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 8908 30 8908 76 {}
N 8868 0 8822 0 {}
N 8908 -30 8908 -76 {}
N 8908 0 8954 0 {}
T {Xd5_d0_g1P1} 8872 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9090 0 0 0 {name=Xd5_d0_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9110 30 9110 76 {}
N 9070 0 9024 0 {}
N 9110 -30 9110 -76 {}
N 9110 0 9156 0 {}
T {Xd5_d0_g1P2} 9074 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 9292 0 0 0 {name=Xd5_d0_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 9312 -30 9312 -76 {}
N 9272 0 9226 0 {}
N 9312 30 9312 76 {}
N 9312 0 9358 0 {}
T {Xd5_d0_g2N0} 9276 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 9494 0 0 0 {name=Xd5_d0_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 9514 -30 9514 -76 {}
N 9474 0 9428 0 {}
N 9514 30 9514 76 {}
N 9514 0 9560 0 {}
T {Xd5_d0_g2N1} 9478 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 9696 0 0 0 {name=Xd5_d0_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 9716 -30 9716 -76 {}
N 9676 0 9630 0 {}
N 9716 30 9716 76 {}
N 9716 0 9762 0 {}
T {Xd5_d0_g2N2} 9680 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9898 0 0 0 {name=Xd5_d0_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9918 30 9918 76 {}
N 9878 0 9832 0 {}
N 9918 -30 9918 -76 {}
N 9918 0 9964 0 {}
T {Xd5_d0_g2P0} 9882 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 10100 0 0 0 {name=Xd5_d0_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 10120 30 10120 76 {}
N 10080 0 10034 0 {}
N 10120 -30 10120 -76 {}
N 10120 0 10166 0 {}
T {Xd5_d0_g2P1} 10084 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 10302 0 0 0 {name=Xd5_d0_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 10322 30 10322 76 {}
N 10282 0 10236 0 {}
N 10322 -30 10322 -76 {}
N 10322 0 10368 0 {}
T {Xd5_d0_g2P2} 10286 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10504 0 0 0 {name=Xd5_d0_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10524 -30 10524 -76 {}
N 10484 0 10438 0 {}
N 10524 30 10524 76 {}
N 10524 0 10570 0 {}
T {Xd5_d0_g3N0} 10488 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10706 0 0 0 {name=Xd5_d0_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10726 -30 10726 -76 {}
N 10686 0 10640 0 {}
N 10726 30 10726 76 {}
N 10726 0 10772 0 {}
T {Xd5_d0_g3N1} 10690 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10908 0 0 0 {name=Xd5_d0_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10928 -30 10928 -76 {}
N 10888 0 10842 0 {}
N 10928 30 10928 76 {}
N 10928 0 10974 0 {}
T {Xd5_d0_g3N2} 10892 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11110 0 0 0 {name=Xd5_d0_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11130 30 11130 76 {}
N 11090 0 11044 0 {}
N 11130 -30 11130 -76 {}
N 11130 0 11176 0 {}
T {Xd5_d0_g3P0} 11094 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11312 0 0 0 {name=Xd5_d0_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11332 30 11332 76 {}
N 11292 0 11246 0 {}
N 11332 -30 11332 -76 {}
N 11332 0 11378 0 {}
T {Xd5_d0_g3P1} 11296 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11514 0 0 0 {name=Xd5_d0_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11534 30 11534 76 {}
N 11494 0 11448 0 {}
N 11534 -30 11534 -76 {}
N 11534 0 11580 0 {}
T {Xd5_d0_g3P2} 11498 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 11716 0 0 0 {name=Xd5_d0_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 11736 -30 11736 -76 {}
N 11696 0 11650 0 {}
N 11736 30 11736 76 {}
N 11736 0 11782 0 {}
T {Xd5_d0_g4N0} 11700 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 11918 0 0 0 {name=Xd5_d0_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 11938 -30 11938 -76 {}
N 11898 0 11852 0 {}
N 11938 30 11938 76 {}
N 11938 0 11984 0 {}
T {Xd5_d0_g4N1} 11902 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 12120 0 0 0 {name=Xd5_d0_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 12140 -30 12140 -76 {}
N 12100 0 12054 0 {}
N 12140 30 12140 76 {}
N 12140 0 12186 0 {}
T {Xd5_d0_g4N2} 12104 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12322 0 0 0 {name=Xd5_d0_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12342 30 12342 76 {}
N 12302 0 12256 0 {}
N 12342 -30 12342 -76 {}
N 12342 0 12388 0 {}
T {Xd5_d0_g4P0} 12306 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12524 0 0 0 {name=Xd5_d0_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12544 30 12544 76 {}
N 12504 0 12458 0 {}
N 12544 -30 12544 -76 {}
N 12544 0 12590 0 {}
T {Xd5_d0_g4P1} 12508 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12726 0 0 0 {name=Xd5_d0_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12746 30 12746 76 {}
N 12706 0 12660 0 {}
N 12746 -30 12746 -76 {}
N 12746 0 12792 0 {}
T {Xd5_d0_g4P2} 12710 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 12928 0 0 0 {name=Xd5_d0_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 12948 -30 12948 -76 {}
N 12908 0 12862 0 {}
N 12948 30 12948 76 {}
N 12948 0 12994 0 {}
T {Xd5_d0_g5N0} 12912 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 13130 0 0 0 {name=Xd5_d0_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 13150 -30 13150 -76 {}
N 13110 0 13064 0 {}
N 13150 30 13150 76 {}
N 13150 0 13196 0 {}
T {Xd5_d0_g5N1} 13114 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 13332 0 0 0 {name=Xd5_d0_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 13352 -30 13352 -76 {}
N 13312 0 13266 0 {}
N 13352 30 13352 76 {}
N 13352 0 13398 0 {}
T {Xd5_d0_g5N2} 13316 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13534 0 0 0 {name=Xd5_d0_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13554 30 13554 76 {}
N 13514 0 13468 0 {}
N 13554 -30 13554 -76 {}
N 13554 0 13600 0 {}
T {Xd5_d0_g5P0} 13518 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13736 0 0 0 {name=Xd5_d0_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13756 30 13756 76 {}
N 13716 0 13670 0 {}
N 13756 -30 13756 -76 {}
N 13756 0 13802 0 {}
T {Xd5_d0_g5P1} 13720 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13938 0 0 0 {name=Xd5_d0_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13958 30 13958 76 {}
N 13918 0 13872 0 {}
N 13958 -30 13958 -76 {}
N 13958 0 14004 0 {}
T {Xd5_d0_g5P2} 13922 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14140 0 0 0 {name=Xd5_d0_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14160 -30 14160 -76 {}
N 14120 0 14074 0 {}
N 14160 30 14160 76 {}
N 14160 0 14206 0 {}
T {Xd5_d0_g6N0} 14124 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14342 0 0 0 {name=Xd5_d0_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14362 -30 14362 -76 {}
N 14322 0 14276 0 {}
N 14362 30 14362 76 {}
N 14362 0 14408 0 {}
T {Xd5_d0_g6N1} 14326 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14544 0 0 0 {name=Xd5_d0_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14564 -30 14564 -76 {}
N 14524 0 14478 0 {}
N 14564 30 14564 76 {}
N 14564 0 14610 0 {}
T {Xd5_d0_g6N2} 14528 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 14746 0 0 0 {name=Xd5_d0_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 14766 30 14766 76 {}
N 14726 0 14680 0 {}
N 14766 -30 14766 -76 {}
N 14766 0 14812 0 {}
T {Xd5_d0_g6P0} 14730 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 14948 0 0 0 {name=Xd5_d0_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 14968 30 14968 76 {}
N 14928 0 14882 0 {}
N 14968 -30 14968 -76 {}
N 14968 0 15014 0 {}
T {Xd5_d0_g6P1} 14932 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15150 0 0 0 {name=Xd5_d0_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15170 30 15170 76 {}
N 15130 0 15084 0 {}
N 15170 -30 15170 -76 {}
N 15170 0 15216 0 {}
T {Xd5_d0_g6P2} 15134 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 15352 0 0 0 {name=Xd5_d1_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 15372 -30 15372 -76 {}
N 15332 0 15286 0 {}
N 15372 30 15372 76 {}
N 15372 0 15418 0 {}
T {Xd5_d1_g1N0} 15336 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 15554 0 0 0 {name=Xd5_d1_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 15574 -30 15574 -76 {}
N 15534 0 15488 0 {}
N 15574 30 15574 76 {}
N 15574 0 15620 0 {}
T {Xd5_d1_g1N1} 15538 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 15756 0 0 0 {name=Xd5_d1_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 15776 -30 15776 -76 {}
N 15736 0 15690 0 {}
N 15776 30 15776 76 {}
N 15776 0 15822 0 {}
T {Xd5_d1_g1N2} 15740 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15958 0 0 0 {name=Xd5_d1_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15978 30 15978 76 {}
N 15938 0 15892 0 {}
N 15978 -30 15978 -76 {}
N 15978 0 16024 0 {}
T {Xd5_d1_g1P0} 15942 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 16160 0 0 0 {name=Xd5_d1_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 16180 30 16180 76 {}
N 16140 0 16094 0 {}
N 16180 -30 16180 -76 {}
N 16180 0 16226 0 {}
T {Xd5_d1_g1P1} 16144 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 16362 0 0 0 {name=Xd5_d1_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 16382 30 16382 76 {}
N 16342 0 16296 0 {}
N 16382 -30 16382 -76 {}
N 16382 0 16428 0 {}
T {Xd5_d1_g1P2} 16346 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16564 0 0 0 {name=Xd5_d1_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16584 -30 16584 -76 {}
N 16544 0 16498 0 {}
N 16584 30 16584 76 {}
N 16584 0 16630 0 {}
T {Xd5_d1_g2N0} 16548 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16766 0 0 0 {name=Xd5_d1_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16786 -30 16786 -76 {}
N 16746 0 16700 0 {}
N 16786 30 16786 76 {}
N 16786 0 16832 0 {}
T {Xd5_d1_g2N1} 16750 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16968 0 0 0 {name=Xd5_d1_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16988 -30 16988 -76 {}
N 16948 0 16902 0 {}
N 16988 30 16988 76 {}
N 16988 0 17034 0 {}
T {Xd5_d1_g2N2} 16952 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17170 0 0 0 {name=Xd5_d1_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17190 30 17190 76 {}
N 17150 0 17104 0 {}
N 17190 -30 17190 -76 {}
N 17190 0 17236 0 {}
T {Xd5_d1_g2P0} 17154 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17372 0 0 0 {name=Xd5_d1_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17392 30 17392 76 {}
N 17352 0 17306 0 {}
N 17392 -30 17392 -76 {}
N 17392 0 17438 0 {}
T {Xd5_d1_g2P1} 17356 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17574 0 0 0 {name=Xd5_d1_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17594 30 17594 76 {}
N 17554 0 17508 0 {}
N 17594 -30 17594 -76 {}
N 17594 0 17640 0 {}
T {Xd5_d1_g2P2} 17558 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 17776 0 0 0 {name=Xd5_d1_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 17796 -30 17796 -76 {}
N 17756 0 17710 0 {}
N 17796 30 17796 76 {}
N 17796 0 17842 0 {}
T {Xd5_d1_g3N0} 17760 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 17978 0 0 0 {name=Xd5_d1_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 17998 -30 17998 -76 {}
N 17958 0 17912 0 {}
N 17998 30 17998 76 {}
N 17998 0 18044 0 {}
T {Xd5_d1_g3N1} 17962 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 18180 0 0 0 {name=Xd5_d1_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 18200 -30 18200 -76 {}
N 18160 0 18114 0 {}
N 18200 30 18200 76 {}
N 18200 0 18246 0 {}
T {Xd5_d1_g3N2} 18164 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 18382 0 0 0 {name=Xd5_d1_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 18402 30 18402 76 {}
N 18362 0 18316 0 {}
N 18402 -30 18402 -76 {}
N 18402 0 18448 0 {}
T {Xd5_d1_g3P0} 18366 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 18584 0 0 0 {name=Xd5_d1_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 18604 30 18604 76 {}
N 18564 0 18518 0 {}
N 18604 -30 18604 -76 {}
N 18604 0 18650 0 {}
T {Xd5_d1_g3P1} 18568 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 18786 0 0 0 {name=Xd5_d1_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 18806 30 18806 76 {}
N 18766 0 18720 0 {}
N 18806 -30 18806 -76 {}
N 18806 0 18852 0 {}
T {Xd5_d1_g3P2} 18770 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 18988 0 0 0 {name=Xd5_d1_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 19008 -30 19008 -76 {}
N 18968 0 18922 0 {}
N 19008 30 19008 76 {}
N 19008 0 19054 0 {}
T {Xd5_d1_g4N0} 18972 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 19190 0 0 0 {name=Xd5_d1_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 19210 -30 19210 -76 {}
N 19170 0 19124 0 {}
N 19210 30 19210 76 {}
N 19210 0 19256 0 {}
T {Xd5_d1_g4N1} 19174 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 19392 0 0 0 {name=Xd5_d1_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 19412 -30 19412 -76 {}
N 19372 0 19326 0 {}
N 19412 30 19412 76 {}
N 19412 0 19458 0 {}
T {Xd5_d1_g4N2} 19376 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 19594 0 0 0 {name=Xd5_d1_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 19614 30 19614 76 {}
N 19574 0 19528 0 {}
N 19614 -30 19614 -76 {}
N 19614 0 19660 0 {}
T {Xd5_d1_g4P0} 19578 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 19796 0 0 0 {name=Xd5_d1_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 19816 30 19816 76 {}
N 19776 0 19730 0 {}
N 19816 -30 19816 -76 {}
N 19816 0 19862 0 {}
T {Xd5_d1_g4P1} 19780 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 19998 0 0 0 {name=Xd5_d1_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 20018 30 20018 76 {}
N 19978 0 19932 0 {}
N 20018 -30 20018 -76 {}
N 20018 0 20064 0 {}
T {Xd5_d1_g4P2} 19982 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 20200 0 0 0 {name=Xd5_d1_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 20220 -30 20220 -76 {}
N 20180 0 20134 0 {}
N 20220 30 20220 76 {}
N 20220 0 20266 0 {}
T {Xd5_d1_g5N0} 20184 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 20402 0 0 0 {name=Xd5_d1_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 20422 -30 20422 -76 {}
N 20382 0 20336 0 {}
N 20422 30 20422 76 {}
N 20422 0 20468 0 {}
T {Xd5_d1_g5N1} 20386 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 20604 0 0 0 {name=Xd5_d1_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 20624 -30 20624 -76 {}
N 20584 0 20538 0 {}
N 20624 30 20624 76 {}
N 20624 0 20670 0 {}
T {Xd5_d1_g5N2} 20588 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 20806 0 0 0 {name=Xd5_d1_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 20826 30 20826 76 {}
N 20786 0 20740 0 {}
N 20826 -30 20826 -76 {}
N 20826 0 20872 0 {}
T {Xd5_d1_g5P0} 20790 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 21008 0 0 0 {name=Xd5_d1_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 21028 30 21028 76 {}
N 20988 0 20942 0 {}
N 21028 -30 21028 -76 {}
N 21028 0 21074 0 {}
T {Xd5_d1_g5P1} 20992 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 21210 0 0 0 {name=Xd5_d1_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 21230 30 21230 76 {}
N 21190 0 21144 0 {}
N 21230 -30 21230 -76 {}
N 21230 0 21276 0 {}
T {Xd5_d1_g5P2} 21194 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 21412 0 0 0 {name=Xd5_d1_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 21432 -30 21432 -76 {}
N 21392 0 21346 0 {}
N 21432 30 21432 76 {}
N 21432 0 21478 0 {}
T {Xd5_d1_g6N0} 21396 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 21614 0 0 0 {name=Xd5_d1_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 21634 -30 21634 -76 {}
N 21594 0 21548 0 {}
N 21634 30 21634 76 {}
N 21634 0 21680 0 {}
T {Xd5_d1_g6N1} 21598 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 21816 0 0 0 {name=Xd5_d1_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 21836 -30 21836 -76 {}
N 21796 0 21750 0 {}
N 21836 30 21836 76 {}
N 21836 0 21882 0 {}
T {Xd5_d1_g6N2} 21800 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 22018 0 0 0 {name=Xd5_d1_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 22038 30 22038 76 {}
N 21998 0 21952 0 {}
N 22038 -30 22038 -76 {}
N 22038 0 22084 0 {}
T {Xd5_d1_g6P0} 22002 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 22220 0 0 0 {name=Xd5_d1_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 22240 30 22240 76 {}
N 22200 0 22154 0 {}
N 22240 -30 22240 -76 {}
N 22240 0 22286 0 {}
T {Xd5_d1_g6P1} 22204 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 22422 0 0 0 {name=Xd5_d1_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 22442 30 22442 76 {}
N 22402 0 22356 0 {}
N 22442 -30 22442 -76 {}
N 22442 0 22488 0 {}
T {Xd5_d1_g6P2} 22406 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 22624 0 0 0 {name=Xd5_d2_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 22644 -30 22644 -76 {}
N 22604 0 22558 0 {}
N 22644 30 22644 76 {}
N 22644 0 22690 0 {}
T {Xd5_d2_g1N0} 22608 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 22826 0 0 0 {name=Xd5_d2_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 22846 -30 22846 -76 {}
N 22806 0 22760 0 {}
N 22846 30 22846 76 {}
N 22846 0 22892 0 {}
T {Xd5_d2_g1N1} 22810 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 23028 0 0 0 {name=Xd5_d2_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 23048 -30 23048 -76 {}
N 23008 0 22962 0 {}
N 23048 30 23048 76 {}
N 23048 0 23094 0 {}
T {Xd5_d2_g1N2} 23012 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 23230 0 0 0 {name=Xd5_d2_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 23250 30 23250 76 {}
N 23210 0 23164 0 {}
N 23250 -30 23250 -76 {}
N 23250 0 23296 0 {}
T {Xd5_d2_g1P0} 23214 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 23432 0 0 0 {name=Xd5_d2_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 23452 30 23452 76 {}
N 23412 0 23366 0 {}
N 23452 -30 23452 -76 {}
N 23452 0 23498 0 {}
T {Xd5_d2_g1P1} 23416 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 23634 0 0 0 {name=Xd5_d2_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 23654 30 23654 76 {}
N 23614 0 23568 0 {}
N 23654 -30 23654 -76 {}
N 23654 0 23700 0 {}
T {Xd5_d2_g1P2} 23618 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 23836 0 0 0 {name=Xd5_d2_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 23856 -30 23856 -76 {}
N 23816 0 23770 0 {}
N 23856 30 23856 76 {}
N 23856 0 23902 0 {}
T {Xd5_d2_g2N0} 23820 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 24038 0 0 0 {name=Xd5_d2_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 24058 -30 24058 -76 {}
N 24018 0 23972 0 {}
N 24058 30 24058 76 {}
N 24058 0 24104 0 {}
T {Xd5_d2_g2N1} 24022 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 24240 0 0 0 {name=Xd5_d2_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 24260 -30 24260 -76 {}
N 24220 0 24174 0 {}
N 24260 30 24260 76 {}
N 24260 0 24306 0 {}
T {Xd5_d2_g2N2} 24224 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 24442 0 0 0 {name=Xd5_d2_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 24462 30 24462 76 {}
N 24422 0 24376 0 {}
N 24462 -30 24462 -76 {}
N 24462 0 24508 0 {}
T {Xd5_d2_g2P0} 24426 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 24644 0 0 0 {name=Xd5_d2_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 24664 30 24664 76 {}
N 24624 0 24578 0 {}
N 24664 -30 24664 -76 {}
N 24664 0 24710 0 {}
T {Xd5_d2_g2P1} 24628 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 24846 0 0 0 {name=Xd5_d2_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 24866 30 24866 76 {}
N 24826 0 24780 0 {}
N 24866 -30 24866 -76 {}
N 24866 0 24912 0 {}
T {Xd5_d2_g2P2} 24830 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 25048 0 0 0 {name=Xd5_d2_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 25068 -30 25068 -76 {}
N 25028 0 24982 0 {}
N 25068 30 25068 76 {}
N 25068 0 25114 0 {}
T {Xd5_d2_g3N0} 25032 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 25250 0 0 0 {name=Xd5_d2_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 25270 -30 25270 -76 {}
N 25230 0 25184 0 {}
N 25270 30 25270 76 {}
N 25270 0 25316 0 {}
T {Xd5_d2_g3N1} 25234 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 25452 0 0 0 {name=Xd5_d2_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 25472 -30 25472 -76 {}
N 25432 0 25386 0 {}
N 25472 30 25472 76 {}
N 25472 0 25518 0 {}
T {Xd5_d2_g3N2} 25436 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 25654 0 0 0 {name=Xd5_d2_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 25674 30 25674 76 {}
N 25634 0 25588 0 {}
N 25674 -30 25674 -76 {}
N 25674 0 25720 0 {}
T {Xd5_d2_g3P0} 25638 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 25856 0 0 0 {name=Xd5_d2_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 25876 30 25876 76 {}
N 25836 0 25790 0 {}
N 25876 -30 25876 -76 {}
N 25876 0 25922 0 {}
T {Xd5_d2_g3P1} 25840 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 26058 0 0 0 {name=Xd5_d2_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 26078 30 26078 76 {}
N 26038 0 25992 0 {}
N 26078 -30 26078 -76 {}
N 26078 0 26124 0 {}
T {Xd5_d2_g3P2} 26042 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 26260 0 0 0 {name=Xd5_d2_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 26280 -30 26280 -76 {}
N 26240 0 26194 0 {}
N 26280 30 26280 76 {}
N 26280 0 26326 0 {}
T {Xd5_d2_g4N0} 26244 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 26462 0 0 0 {name=Xd5_d2_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 26482 -30 26482 -76 {}
N 26442 0 26396 0 {}
N 26482 30 26482 76 {}
N 26482 0 26528 0 {}
T {Xd5_d2_g4N1} 26446 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 26664 0 0 0 {name=Xd5_d2_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 26684 -30 26684 -76 {}
N 26644 0 26598 0 {}
N 26684 30 26684 76 {}
N 26684 0 26730 0 {}
T {Xd5_d2_g4N2} 26648 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 26866 0 0 0 {name=Xd5_d2_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 26886 30 26886 76 {}
N 26846 0 26800 0 {}
N 26886 -30 26886 -76 {}
N 26886 0 26932 0 {}
T {Xd5_d2_g4P0} 26850 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 27068 0 0 0 {name=Xd5_d2_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 27088 30 27088 76 {}
N 27048 0 27002 0 {}
N 27088 -30 27088 -76 {}
N 27088 0 27134 0 {}
T {Xd5_d2_g4P1} 27052 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 27270 0 0 0 {name=Xd5_d2_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 27290 30 27290 76 {}
N 27250 0 27204 0 {}
N 27290 -30 27290 -76 {}
N 27290 0 27336 0 {}
T {Xd5_d2_g4P2} 27254 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 27472 0 0 0 {name=Xd5_d2_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 27492 -30 27492 -76 {}
N 27452 0 27406 0 {}
N 27492 30 27492 76 {}
N 27492 0 27538 0 {}
T {Xd5_d2_g5N0} 27456 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 27674 0 0 0 {name=Xd5_d2_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 27694 -30 27694 -76 {}
N 27654 0 27608 0 {}
N 27694 30 27694 76 {}
N 27694 0 27740 0 {}
T {Xd5_d2_g5N1} 27658 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 27876 0 0 0 {name=Xd5_d2_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 27896 -30 27896 -76 {}
N 27856 0 27810 0 {}
N 27896 30 27896 76 {}
N 27896 0 27942 0 {}
T {Xd5_d2_g5N2} 27860 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 28078 0 0 0 {name=Xd5_d2_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 28098 30 28098 76 {}
N 28058 0 28012 0 {}
N 28098 -30 28098 -76 {}
N 28098 0 28144 0 {}
T {Xd5_d2_g5P0} 28062 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 28280 0 0 0 {name=Xd5_d2_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 28300 30 28300 76 {}
N 28260 0 28214 0 {}
N 28300 -30 28300 -76 {}
N 28300 0 28346 0 {}
T {Xd5_d2_g5P1} 28264 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 28482 0 0 0 {name=Xd5_d2_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 28502 30 28502 76 {}
N 28462 0 28416 0 {}
N 28502 -30 28502 -76 {}
N 28502 0 28548 0 {}
T {Xd5_d2_g5P2} 28466 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 28684 0 0 0 {name=Xd5_d2_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 28704 -30 28704 -76 {}
N 28664 0 28618 0 {}
N 28704 30 28704 76 {}
N 28704 0 28750 0 {}
T {Xd5_d2_g6N0} 28668 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 28886 0 0 0 {name=Xd5_d2_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 28906 -30 28906 -76 {}
N 28866 0 28820 0 {}
N 28906 30 28906 76 {}
N 28906 0 28952 0 {}
T {Xd5_d2_g6N1} 28870 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 29088 0 0 0 {name=Xd5_d2_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 29108 -30 29108 -76 {}
N 29068 0 29022 0 {}
N 29108 30 29108 76 {}
N 29108 0 29154 0 {}
T {Xd5_d2_g6N2} 29072 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 29290 0 0 0 {name=Xd5_d2_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 29310 30 29310 76 {}
N 29270 0 29224 0 {}
N 29310 -30 29310 -76 {}
N 29310 0 29356 0 {}
T {Xd5_d2_g6P0} 29274 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 29492 0 0 0 {name=Xd5_d2_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 29512 30 29512 76 {}
N 29472 0 29426 0 {}
N 29512 -30 29512 -76 {}
N 29512 0 29558 0 {}
T {Xd5_d2_g6P1} 29476 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 29694 0 0 0 {name=Xd5_d2_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 29714 30 29714 76 {}
N 29674 0 29628 0 {}
N 29714 -30 29714 -76 {}
N 29714 0 29760 0 {}
T {Xd5_d2_g6P2} 29678 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 29896 0 0 0 {name=Xd2_inv1N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 29916 -30 29916 -76 {}
N 29876 0 29830 0 {}
N 29916 30 29916 76 {}
N 29916 0 29962 0 {}
T {Xd2_inv1N} 29880 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 30098 0 0 0 {name=Xd2_inv1P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 30118 30 30118 76 {}
N 30078 0 30032 0 {}
N 30118 -30 30118 -76 {}
N 30118 0 30164 0 {}
T {Xd2_inv1P} 30082 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 30300 0 0 0 {name=Xd2_inv2N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 30320 -30 30320 -76 {}
N 30280 0 30234 0 {}
N 30320 30 30320 76 {}
N 30320 0 30366 0 {}
T {Xd2_inv2N} 30284 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 30502 0 0 0 {name=Xd2_inv2P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 30522 30 30522 76 {}
N 30482 0 30436 0 {}
N 30522 -30 30522 -76 {}
N 30522 0 30568 0 {}
T {Xd2_inv2P} 30486 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 30704 0 0 0 {name=Xd2_inv3N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 30724 -30 30724 -76 {}
N 30684 0 30638 0 {}
N 30724 30 30724 76 {}
N 30724 0 30770 0 {}
T {Xd2_inv3N} 30688 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 30906 0 0 0 {name=Xd2_inv3P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 30926 30 30926 76 {}
N 30886 0 30840 0 {}
N 30926 -30 30926 -76 {}
N 30926 0 30972 0 {}
T {Xd2_inv3P} 30890 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 31108 0 0 0 {name=Xd2_inv4N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 31128 -30 31128 -76 {}
N 31088 0 31042 0 {}
N 31128 30 31128 76 {}
N 31128 0 31174 0 {}
T {Xd2_inv4N} 31092 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 31310 0 0 0 {name=Xd2_inv4P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 31330 30 31330 76 {}
N 31290 0 31244 0 {}
N 31330 -30 31330 -76 {}
N 31330 0 31376 0 {}
T {Xd2_inv4P} 31294 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 31512 0 0 0 {name=Xd2_dff_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 31532 -30 31532 -76 {}
N 31492 0 31446 0 {}
N 31532 30 31532 76 {}
N 31532 0 31578 0 {}
T {Xd2_dff_g1N0} 31496 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 31714 0 0 0 {name=Xd2_dff_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 31734 -30 31734 -76 {}
N 31694 0 31648 0 {}
N 31734 30 31734 76 {}
N 31734 0 31780 0 {}
T {Xd2_dff_g1N1} 31698 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 31916 0 0 0 {name=Xd2_dff_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 31936 -30 31936 -76 {}
N 31896 0 31850 0 {}
N 31936 30 31936 76 {}
N 31936 0 31982 0 {}
T {Xd2_dff_g1N2} 31900 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 32118 0 0 0 {name=Xd2_dff_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 32138 30 32138 76 {}
N 32098 0 32052 0 {}
N 32138 -30 32138 -76 {}
N 32138 0 32184 0 {}
T {Xd2_dff_g1P0} 32102 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 32320 0 0 0 {name=Xd2_dff_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 32340 30 32340 76 {}
N 32300 0 32254 0 {}
N 32340 -30 32340 -76 {}
N 32340 0 32386 0 {}
T {Xd2_dff_g1P1} 32304 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 32522 0 0 0 {name=Xd2_dff_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 32542 30 32542 76 {}
N 32502 0 32456 0 {}
N 32542 -30 32542 -76 {}
N 32542 0 32588 0 {}
T {Xd2_dff_g1P2} 32506 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 32724 0 0 0 {name=Xd2_dff_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 32744 -30 32744 -76 {}
N 32704 0 32658 0 {}
N 32744 30 32744 76 {}
N 32744 0 32790 0 {}
T {Xd2_dff_g2N0} 32708 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 32926 0 0 0 {name=Xd2_dff_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 32946 -30 32946 -76 {}
N 32906 0 32860 0 {}
N 32946 30 32946 76 {}
N 32946 0 32992 0 {}
T {Xd2_dff_g2N1} 32910 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 33128 0 0 0 {name=Xd2_dff_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 33148 -30 33148 -76 {}
N 33108 0 33062 0 {}
N 33148 30 33148 76 {}
N 33148 0 33194 0 {}
T {Xd2_dff_g2N2} 33112 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 33330 0 0 0 {name=Xd2_dff_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 33350 30 33350 76 {}
N 33310 0 33264 0 {}
N 33350 -30 33350 -76 {}
N 33350 0 33396 0 {}
T {Xd2_dff_g2P0} 33314 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 33532 0 0 0 {name=Xd2_dff_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 33552 30 33552 76 {}
N 33512 0 33466 0 {}
N 33552 -30 33552 -76 {}
N 33552 0 33598 0 {}
T {Xd2_dff_g2P1} 33516 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 33734 0 0 0 {name=Xd2_dff_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 33754 30 33754 76 {}
N 33714 0 33668 0 {}
N 33754 -30 33754 -76 {}
N 33754 0 33800 0 {}
T {Xd2_dff_g2P2} 33718 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 33936 0 0 0 {name=Xd2_dff_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 33956 -30 33956 -76 {}
N 33916 0 33870 0 {}
N 33956 30 33956 76 {}
N 33956 0 34002 0 {}
T {Xd2_dff_g3N0} 33920 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 34138 0 0 0 {name=Xd2_dff_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 34158 -30 34158 -76 {}
N 34118 0 34072 0 {}
N 34158 30 34158 76 {}
N 34158 0 34204 0 {}
T {Xd2_dff_g3N1} 34122 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 34340 0 0 0 {name=Xd2_dff_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 34360 -30 34360 -76 {}
N 34320 0 34274 0 {}
N 34360 30 34360 76 {}
N 34360 0 34406 0 {}
T {Xd2_dff_g3N2} 34324 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 34542 0 0 0 {name=Xd2_dff_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 34562 30 34562 76 {}
N 34522 0 34476 0 {}
N 34562 -30 34562 -76 {}
N 34562 0 34608 0 {}
T {Xd2_dff_g3P0} 34526 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 34744 0 0 0 {name=Xd2_dff_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 34764 30 34764 76 {}
N 34724 0 34678 0 {}
N 34764 -30 34764 -76 {}
N 34764 0 34810 0 {}
T {Xd2_dff_g3P1} 34728 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 34946 0 0 0 {name=Xd2_dff_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 34966 30 34966 76 {}
N 34926 0 34880 0 {}
N 34966 -30 34966 -76 {}
N 34966 0 35012 0 {}
T {Xd2_dff_g3P2} 34930 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 35148 0 0 0 {name=Xd2_dff_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 35168 -30 35168 -76 {}
N 35128 0 35082 0 {}
N 35168 30 35168 76 {}
N 35168 0 35214 0 {}
T {Xd2_dff_g4N0} 35132 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 35350 0 0 0 {name=Xd2_dff_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 35370 -30 35370 -76 {}
N 35330 0 35284 0 {}
N 35370 30 35370 76 {}
N 35370 0 35416 0 {}
T {Xd2_dff_g4N1} 35334 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 35552 0 0 0 {name=Xd2_dff_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 35572 -30 35572 -76 {}
N 35532 0 35486 0 {}
N 35572 30 35572 76 {}
N 35572 0 35618 0 {}
T {Xd2_dff_g4N2} 35536 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 35754 0 0 0 {name=Xd2_dff_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 35774 30 35774 76 {}
N 35734 0 35688 0 {}
N 35774 -30 35774 -76 {}
N 35774 0 35820 0 {}
T {Xd2_dff_g4P0} 35738 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 35956 0 0 0 {name=Xd2_dff_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 35976 30 35976 76 {}
N 35936 0 35890 0 {}
N 35976 -30 35976 -76 {}
N 35976 0 36022 0 {}
T {Xd2_dff_g4P1} 35940 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 36158 0 0 0 {name=Xd2_dff_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 36178 30 36178 76 {}
N 36138 0 36092 0 {}
N 36178 -30 36178 -76 {}
N 36178 0 36224 0 {}
T {Xd2_dff_g4P2} 36142 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 36360 0 0 0 {name=Xd2_dff_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 36380 -30 36380 -76 {}
N 36340 0 36294 0 {}
N 36380 30 36380 76 {}
N 36380 0 36426 0 {}
T {Xd2_dff_g5N0} 36344 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 36562 0 0 0 {name=Xd2_dff_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 36582 -30 36582 -76 {}
N 36542 0 36496 0 {}
N 36582 30 36582 76 {}
N 36582 0 36628 0 {}
T {Xd2_dff_g5N1} 36546 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 36764 0 0 0 {name=Xd2_dff_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 36784 -30 36784 -76 {}
N 36744 0 36698 0 {}
N 36784 30 36784 76 {}
N 36784 0 36830 0 {}
T {Xd2_dff_g5N2} 36748 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 36966 0 0 0 {name=Xd2_dff_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 36986 30 36986 76 {}
N 36946 0 36900 0 {}
N 36986 -30 36986 -76 {}
N 36986 0 37032 0 {}
T {Xd2_dff_g5P0} 36950 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 37168 0 0 0 {name=Xd2_dff_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 37188 30 37188 76 {}
N 37148 0 37102 0 {}
N 37188 -30 37188 -76 {}
N 37188 0 37234 0 {}
T {Xd2_dff_g5P1} 37152 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 37370 0 0 0 {name=Xd2_dff_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 37390 30 37390 76 {}
N 37350 0 37304 0 {}
N 37390 -30 37390 -76 {}
N 37390 0 37436 0 {}
T {Xd2_dff_g5P2} 37354 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 37572 0 0 0 {name=Xd2_dff_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 37592 -30 37592 -76 {}
N 37552 0 37506 0 {}
N 37592 30 37592 76 {}
N 37592 0 37638 0 {}
T {Xd2_dff_g6N0} 37556 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 37774 0 0 0 {name=Xd2_dff_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 37794 -30 37794 -76 {}
N 37754 0 37708 0 {}
N 37794 30 37794 76 {}
N 37794 0 37840 0 {}
T {Xd2_dff_g6N1} 37758 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 37976 0 0 0 {name=Xd2_dff_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 37996 -30 37996 -76 {}
N 37956 0 37910 0 {}
N 37996 30 37996 76 {}
N 37996 0 38042 0 {}
T {Xd2_dff_g6N2} 37960 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 38178 0 0 0 {name=Xd2_dff_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 38198 30 38198 76 {}
N 38158 0 38112 0 {}
N 38198 -30 38198 -76 {}
N 38198 0 38244 0 {}
T {Xd2_dff_g6P0} 38162 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 38380 0 0 0 {name=Xd2_dff_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 38400 30 38400 76 {}
N 38360 0 38314 0 {}
N 38400 -30 38400 -76 {}
N 38400 0 38446 0 {}
T {Xd2_dff_g6P1} 38364 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 38582 0 0 0 {name=Xd2_dff_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 38602 30 38602 76 {}
N 38562 0 38516 0 {}
N 38602 -30 38602 -76 {}
N 38602 0 38648 0 {}
T {Xd2_dff_g6P2} 38566 76 0 0 0.11 0.11 {layer=13}
N 20 -76 20 -116 {}
N -66 0 -66 116 {}
N 540 0 540 116 {}
N 13266 0 13266 116 {}
N 13872 0 13872 116 {}
N 14766 76 14766 116 {}
N 14968 76 14968 116 {}
N 15170 76 15170 116 {}
N 20 76 20 2076 {}
N 66 0 66 2076 {}
N 268 0 268 2076 {}
N 470 0 470 2076 {}
N 1232 76 1232 2076 {}
N 1278 0 1278 2076 {}
N 1636 76 1636 2076 {}
N 1682 0 1682 2076 {}
N 1884 0 1884 2076 {}
N 2086 0 2086 2076 {}
N 2848 76 2848 2076 {}
N 2894 0 2894 2076 {}
N 3252 76 3252 2076 {}
N 3298 0 3298 2076 {}
N 3500 0 3500 2076 {}
N 3702 0 3702 2076 {}
N 4464 76 4464 2076 {}
N 4510 0 4510 2076 {}
N 4712 0 4712 2076 {}
N 4914 0 4914 2076 {}
N 5676 76 5676 2076 {}
N 5722 0 5722 2076 {}
N 5924 0 5924 2076 {}
N 6126 0 6126 2076 {}
N 6888 76 6888 2076 {}
N 6934 0 6934 2076 {}
N 7136 0 7136 2076 {}
N 7338 0 7338 2076 {}
N 8100 76 8100 2076 {}
N 8146 0 8146 2076 {}
N 8348 0 8348 2076 {}
N 8550 0 8550 2076 {}
N 9312 76 9312 2076 {}
N 9358 0 9358 2076 {}
N 9560 0 9560 2076 {}
N 9762 0 9762 2076 {}
N 10524 76 10524 2076 {}
N 10570 0 10570 2076 {}
N 10772 0 10772 2076 {}
N 10974 0 10974 2076 {}
N 11736 76 11736 2076 {}
N 11782 0 11782 2076 {}
N 11984 0 11984 2076 {}
N 12186 0 12186 2076 {}
N 12948 76 12948 2076 {}
N 12994 0 12994 2076 {}
N 13196 0 13196 2076 {}
N 13398 0 13398 2076 {}
N 14160 76 14160 2076 {}
N 14206 0 14206 2076 {}
N 14408 0 14408 2076 {}
N 14610 0 14610 2076 {}
N 15372 76 15372 2076 {}
N 15418 0 15418 2076 {}
N 15620 0 15620 2076 {}
N 15822 0 15822 2076 {}
N 16584 76 16584 2076 {}
N 16630 0 16630 2076 {}
N 16832 0 16832 2076 {}
N 17034 0 17034 2076 {}
N 17796 76 17796 2076 {}
N 17842 0 17842 2076 {}
N 18044 0 18044 2076 {}
N 18246 0 18246 2076 {}
N 19008 76 19008 2076 {}
N 19054 0 19054 2076 {}
N 19256 0 19256 2076 {}
N 19458 0 19458 2076 {}
N 20220 76 20220 2076 {}
N 20266 0 20266 2076 {}
N 20468 0 20468 2076 {}
N 20670 0 20670 2076 {}
N 21432 76 21432 2076 {}
N 21478 0 21478 2076 {}
N 21680 0 21680 2076 {}
N 21882 0 21882 2076 {}
N 22644 76 22644 2076 {}
N 22690 0 22690 2076 {}
N 22892 0 22892 2076 {}
N 23094 0 23094 2076 {}
N 23856 76 23856 2076 {}
N 23902 0 23902 2076 {}
N 24104 0 24104 2076 {}
N 24306 0 24306 2076 {}
N 25068 76 25068 2076 {}
N 25114 0 25114 2076 {}
N 25316 0 25316 2076 {}
N 25518 0 25518 2076 {}
N 26280 76 26280 2076 {}
N 26326 0 26326 2076 {}
N 26528 0 26528 2076 {}
N 26730 0 26730 2076 {}
N 27492 76 27492 2076 {}
N 27538 0 27538 2076 {}
N 27740 0 27740 2076 {}
N 27942 0 27942 2076 {}
N 28704 76 28704 2076 {}
N 28750 0 28750 2076 {}
N 28952 0 28952 2076 {}
N 29154 0 29154 2076 {}
N 29916 76 29916 2076 {}
N 29962 0 29962 2076 {}
N 30320 76 30320 2076 {}
N 30366 0 30366 2076 {}
N 30724 76 30724 2076 {}
N 30770 0 30770 2076 {}
N 31128 76 31128 2076 {}
N 31174 0 31174 2076 {}
N 31532 76 31532 2076 {}
N 31578 0 31578 2076 {}
N 31780 0 31780 2076 {}
N 31982 0 31982 2076 {}
N 32744 76 32744 2076 {}
N 32790 0 32790 2076 {}
N 32992 0 32992 2076 {}
N 33194 0 33194 2076 {}
N 33956 76 33956 2076 {}
N 34002 0 34002 2076 {}
N 34204 0 34204 2076 {}
N 34406 0 34406 2076 {}
N 35168 76 35168 2076 {}
N 35214 0 35214 2076 {}
N 35416 0 35416 2076 {}
N 35618 0 35618 2076 {}
N 36380 76 36380 2076 {}
N 36426 0 36426 2076 {}
N 36628 0 36628 2076 {}
N 36830 0 36830 2076 {}
N 37592 76 37592 2076 {}
N 37638 0 37638 2076 {}
N 37840 0 37840 2076 {}
N 38042 0 38042 2076 {}
N 222 -76 222 -180 {}
N 136 0 136 180 {}
N 742 0 742 180 {}
N 27810 0 27810 180 {}
N 28416 0 28416 180 {}
N 29310 76 29310 180 {}
N 29512 76 29512 180 {}
N 29714 76 29714 180 {}
N 626 76 626 244 {}
N 828 76 828 244 {}
N 1030 76 1030 244 {}
N 1146 0 1146 244 {}
N 1348 0 1348 244 {}
N 338 0 338 -4444 {}
N 626 -76 626 -4444 {}
N 672 0 672 -4444 {}
N 828 -76 828 -4444 {}
N 874 0 874 -4444 {}
N 944 0 944 -4444 {}
N 1030 -76 1030 -4444 {}
N 1076 0 1076 -4444 {}
N 1434 -76 1434 -4444 {}
N 1480 0 1480 -4444 {}
N 1954 0 1954 -4444 {}
N 2242 -76 2242 -4444 {}
N 2288 0 2288 -4444 {}
N 2444 -76 2444 -4444 {}
N 2490 0 2490 -4444 {}
N 2560 0 2560 -4444 {}
N 2646 -76 2646 -4444 {}
N 2692 0 2692 -4444 {}
N 3050 -76 3050 -4444 {}
N 3096 0 3096 -4444 {}
N 3570 0 3570 -4444 {}
N 3858 -76 3858 -4444 {}
N 3904 0 3904 -4444 {}
N 4060 -76 4060 -4444 {}
N 4106 0 4106 -4444 {}
N 4176 0 4176 -4444 {}
N 4262 -76 4262 -4444 {}
N 4308 0 4308 -4444 {}
N 4782 0 4782 -4444 {}
N 5070 -76 5070 -4444 {}
N 5116 0 5116 -4444 {}
N 5272 -76 5272 -4444 {}
N 5318 0 5318 -4444 {}
N 5388 0 5388 -4444 {}
N 5474 -76 5474 -4444 {}
N 5520 0 5520 -4444 {}
N 5994 0 5994 -4444 {}
N 6282 -76 6282 -4444 {}
N 6328 0 6328 -4444 {}
N 6484 -76 6484 -4444 {}
N 6530 0 6530 -4444 {}
N 6600 0 6600 -4444 {}
N 6686 -76 6686 -4444 {}
N 6732 0 6732 -4444 {}
N 7206 0 7206 -4444 {}
N 7494 -76 7494 -4444 {}
N 7540 0 7540 -4444 {}
N 7696 -76 7696 -4444 {}
N 7742 0 7742 -4444 {}
N 7812 0 7812 -4444 {}
N 7898 -76 7898 -4444 {}
N 7944 0 7944 -4444 {}
N 8014 0 8014 -4444 {}
N 8620 0 8620 -4444 {}
N 8706 -76 8706 -4444 {}
N 8752 0 8752 -4444 {}
N 8908 -76 8908 -4444 {}
N 8954 0 8954 -4444 {}
N 9110 -76 9110 -4444 {}
N 9156 0 9156 -4444 {}
N 9630 0 9630 -4444 {}
N 9918 -76 9918 -4444 {}
N 9964 0 9964 -4444 {}
N 10120 -76 10120 -4444 {}
N 10166 0 10166 -4444 {}
N 10236 0 10236 -4444 {}
N 10322 -76 10322 -4444 {}
N 10368 0 10368 -4444 {}
N 11130 -76 11130 -4444 {}
N 11176 0 11176 -4444 {}
N 11332 -76 11332 -4444 {}
N 11378 0 11378 -4444 {}
N 11534 -76 11534 -4444 {}
N 11580 0 11580 -4444 {}
N 11852 0 11852 -4444 {}
N 12342 -76 12342 -4444 {}
N 12388 0 12388 -4444 {}
N 12458 0 12458 -4444 {}
N 12544 -76 12544 -4444 {}
N 12590 0 12590 -4444 {}
N 12746 -76 12746 -4444 {}
N 12792 0 12792 -4444 {}
N 12862 0 12862 -4444 {}
N 13468 0 13468 -4444 {}
N 13554 -76 13554 -4444 {}
N 13600 0 13600 -4444 {}
N 13756 -76 13756 -4444 {}
N 13802 0 13802 -4444 {}
N 13958 -76 13958 -4444 {}
N 14004 0 14004 -4444 {}
N 14478 0 14478 -4444 {}
N 14766 -76 14766 -4444 {}
N 14812 0 14812 -4444 {}
N 14968 -76 14968 -4444 {}
N 15014 0 15014 -4444 {}
N 15084 0 15084 -4444 {}
N 15170 -76 15170 -4444 {}
N 15216 0 15216 -4444 {}
N 15286 0 15286 -4444 {}
N 15892 0 15892 -4444 {}
N 15978 -76 15978 -4444 {}
N 16024 0 16024 -4444 {}
N 16180 -76 16180 -4444 {}
N 16226 0 16226 -4444 {}
N 16382 -76 16382 -4444 {}
N 16428 0 16428 -4444 {}
N 16902 0 16902 -4444 {}
N 17190 -76 17190 -4444 {}
N 17236 0 17236 -4444 {}
N 17392 -76 17392 -4444 {}
N 17438 0 17438 -4444 {}
N 17508 0 17508 -4444 {}
N 17594 -76 17594 -4444 {}
N 17640 0 17640 -4444 {}
N 18402 -76 18402 -4444 {}
N 18448 0 18448 -4444 {}
N 18604 -76 18604 -4444 {}
N 18650 0 18650 -4444 {}
N 18806 -76 18806 -4444 {}
N 18852 0 18852 -4444 {}
N 19124 0 19124 -4444 {}
N 19614 -76 19614 -4444 {}
N 19660 0 19660 -4444 {}
N 19730 0 19730 -4444 {}
N 19816 -76 19816 -4444 {}
N 19862 0 19862 -4444 {}
N 20018 -76 20018 -4444 {}
N 20064 0 20064 -4444 {}
N 20134 0 20134 -4444 {}
N 20740 0 20740 -4444 {}
N 20826 -76 20826 -4444 {}
N 20872 0 20872 -4444 {}
N 21028 -76 21028 -4444 {}
N 21074 0 21074 -4444 {}
N 21230 -76 21230 -4444 {}
N 21276 0 21276 -4444 {}
N 21750 0 21750 -4444 {}
N 22038 -76 22038 -4444 {}
N 22084 0 22084 -4444 {}
N 22240 -76 22240 -4444 {}
N 22286 0 22286 -4444 {}
N 22356 0 22356 -4444 {}
N 22442 -76 22442 -4444 {}
N 22488 0 22488 -4444 {}
N 22558 0 22558 -4444 {}
N 23164 0 23164 -4444 {}
N 23250 -76 23250 -4444 {}
N 23296 0 23296 -4444 {}
N 23452 -76 23452 -4444 {}
N 23498 0 23498 -4444 {}
N 23654 -76 23654 -4444 {}
N 23700 0 23700 -4444 {}
N 24174 0 24174 -4444 {}
N 24462 -76 24462 -4444 {}
N 24508 0 24508 -4444 {}
N 24664 -76 24664 -4444 {}
N 24710 0 24710 -4444 {}
N 24780 0 24780 -4444 {}
N 24866 -76 24866 -4444 {}
N 24912 0 24912 -4444 {}
N 25674 -76 25674 -4444 {}
N 25720 0 25720 -4444 {}
N 25876 -76 25876 -4444 {}
N 25922 0 25922 -4444 {}
N 26078 -76 26078 -4444 {}
N 26124 0 26124 -4444 {}
N 26396 0 26396 -4444 {}
N 26886 -76 26886 -4444 {}
N 26932 0 26932 -4444 {}
N 27002 0 27002 -4444 {}
N 27088 -76 27088 -4444 {}
N 27134 0 27134 -4444 {}
N 27290 -76 27290 -4444 {}
N 27336 0 27336 -4444 {}
N 27406 0 27406 -4444 {}
N 28012 0 28012 -4444 {}
N 28098 -76 28098 -4444 {}
N 28144 0 28144 -4444 {}
N 28300 -76 28300 -4444 {}
N 28346 0 28346 -4444 {}
N 28502 -76 28502 -4444 {}
N 28548 0 28548 -4444 {}
N 29022 0 29022 -4444 {}
N 29310 -76 29310 -4444 {}
N 29356 0 29356 -4444 {}
N 29512 -76 29512 -4444 {}
N 29558 0 29558 -4444 {}
N 29628 0 29628 -4444 {}
N 29714 -76 29714 -4444 {}
N 29760 0 29760 -4444 {}
N 30118 -76 30118 -4444 {}
N 30164 0 30164 -4444 {}
N 30522 -76 30522 -4444 {}
N 30568 0 30568 -4444 {}
N 30926 -76 30926 -4444 {}
N 30972 0 30972 -4444 {}
N 31330 -76 31330 -4444 {}
N 31376 0 31376 -4444 {}
N 31446 0 31446 -4444 {}
N 32052 0 32052 -4444 {}
N 32138 -76 32138 -4444 {}
N 32184 0 32184 -4444 {}
N 32340 -76 32340 -4444 {}
N 32386 0 32386 -4444 {}
N 32542 -76 32542 -4444 {}
N 32588 0 32588 -4444 {}
N 33062 0 33062 -4444 {}
N 33350 -76 33350 -4444 {}
N 33396 0 33396 -4444 {}
N 33552 -76 33552 -4444 {}
N 33598 0 33598 -4444 {}
N 33668 0 33668 -4444 {}
N 33754 -76 33754 -4444 {}
N 33800 0 33800 -4444 {}
N 34562 -76 34562 -4444 {}
N 34608 0 34608 -4444 {}
N 34764 -76 34764 -4444 {}
N 34810 0 34810 -4444 {}
N 34966 -76 34966 -4444 {}
N 35012 0 35012 -4444 {}
N 35284 0 35284 -4444 {}
N 35774 -76 35774 -4444 {}
N 35820 0 35820 -4444 {}
N 35890 0 35890 -4444 {}
N 35976 -76 35976 -4444 {}
N 36022 0 36022 -4444 {}
N 36178 -76 36178 -4444 {}
N 36224 0 36224 -4444 {}
N 36294 0 36294 -4444 {}
N 36900 0 36900 -4444 {}
N 36986 -76 36986 -4444 {}
N 37032 0 37032 -4444 {}
N 37188 -76 37188 -4444 {}
N 37234 0 37234 -4444 {}
N 37390 -76 37390 -4444 {}
N 37436 0 37436 -4444 {}
N 37910 0 37910 -4444 {}
N 38198 -76 38198 -4444 {}
N 38244 0 38244 -4444 {}
N 38400 -76 38400 -4444 {}
N 38446 0 38446 -4444 {}
N 38516 0 38516 -4444 {}
N 38602 -76 38602 -4444 {}
N 38648 0 38648 -4444 {}
N 1232 -76 1232 -244 {}
N 12054 0 12054 -244 {}
N 12660 0 12660 -244 {}
N 1636 -76 1636 -308 {}
N 1550 0 1550 308 {}
N 2156 0 2156 308 {}
N 3166 0 3166 308 {}
N 3772 0 3772 308 {}
N 4378 0 4378 308 {}
N 4984 0 4984 308 {}
N 13554 76 13554 308 {}
N 13756 76 13756 308 {}
N 13958 76 13958 308 {}
N 14074 0 14074 308 {}
N 14680 0 14680 308 {}
N 1838 -76 1838 -372 {}
N 1752 0 1752 372 {}
N 2358 0 2358 372 {}
N 3368 0 3368 372 {}
N 3974 0 3974 372 {}
N 5590 0 5590 372 {}
N 6196 0 6196 372 {}
N 20826 76 20826 372 {}
N 21028 76 21028 372 {}
N 21230 76 21230 372 {}
N 21346 0 21346 372 {}
N 21952 0 21952 372 {}
N 2242 76 2242 436 {}
N 2444 76 2444 436 {}
N 2646 76 2646 436 {}
N 2762 0 2762 436 {}
N 2964 0 2964 436 {}
N 2848 -76 2848 -436 {}
N 26598 0 26598 -436 {}
N 27204 0 27204 -436 {}
N 3252 -76 3252 -500 {}
N 3454 -76 3454 -564 {}
N 3858 76 3858 500 {}
N 4060 76 4060 500 {}
N 4262 76 4262 500 {}
N 4580 0 4580 500 {}
N 5186 0 5186 500 {}
N 5792 0 5792 500 {}
N 6398 0 6398 500 {}
N 4464 -76 4464 -628 {}
N 4666 -76 4666 -692 {}
N 5070 76 5070 564 {}
N 5272 76 5272 564 {}
N 5474 76 5474 564 {}
N 6802 0 6802 564 {}
N 7408 0 7408 564 {}
N 5676 -76 5676 -756 {}
N 5878 -76 5878 -820 {}
N 6282 76 6282 628 {}
N 6484 76 6484 628 {}
N 6686 76 6686 628 {}
N 7004 0 7004 628 {}
N 7610 0 7610 628 {}
N 6888 -76 6888 -884 {}
N 7090 -76 7090 -948 {}
N 7494 76 7494 692 {}
N 7696 76 7696 692 {}
N 7898 76 7898 692 {}
N 19326 0 19326 692 {}
N 19932 0 19932 692 {}
N 8100 -76 8100 -1012 {}
N 8302 -76 8302 -1076 {}
N 8216 0 8216 756 {}
N 8822 0 8822 756 {}
N 10842 0 10842 756 {}
N 11448 0 11448 756 {}
N 12342 76 12342 756 {}
N 12544 76 12544 756 {}
N 12746 76 12746 756 {}
N 8706 76 8706 820 {}
N 8908 76 8908 820 {}
N 9110 76 9110 820 {}
N 9226 0 9226 820 {}
N 9832 0 9832 820 {}
N 8418 0 8418 884 {}
N 9024 0 9024 884 {}
N 9918 76 9918 884 {}
N 10120 76 10120 884 {}
N 10322 76 10322 884 {}
N 10438 0 10438 884 {}
N 11044 0 11044 884 {}
N 13064 0 13064 884 {}
N 13670 0 13670 884 {}
N 9312 -76 9312 -1140 {}
N 9514 -76 9514 -1204 {}
N 9428 0 9428 -1268 {}
N 10034 0 10034 -1268 {}
N 10640 0 10640 -1268 {}
N 11246 0 11246 -1268 {}
N 16700 0 16700 -1268 {}
N 17306 0 17306 -1268 {}
N 17912 0 17912 -1268 {}
N 18518 0 18518 -1268 {}
N 23972 0 23972 -1268 {}
N 24578 0 24578 -1268 {}
N 25184 0 25184 -1268 {}
N 25790 0 25790 -1268 {}
N 10524 -76 10524 -1332 {}
N 10726 -76 10726 -1396 {}
N 11130 76 11130 948 {}
N 11332 76 11332 948 {}
N 11534 76 11534 948 {}
N 11650 0 11650 948 {}
N 12256 0 12256 948 {}
N 14276 0 14276 948 {}
N 14882 0 14882 948 {}
N 11736 -76 11736 -1460 {}
N 11938 -76 11938 -1524 {}
N 12948 -76 12948 -1588 {}
N 13150 -76 13150 -1652 {}
N 14160 -76 14160 -1716 {}
N 14362 -76 14362 -1780 {}
N 15372 -76 15372 -1844 {}
N 15574 -76 15574 -1908 {}
N 15488 0 15488 1012 {}
N 16094 0 16094 1012 {}
N 18114 0 18114 1012 {}
N 18720 0 18720 1012 {}
N 19614 76 19614 1012 {}
N 19816 76 19816 1012 {}
N 20018 76 20018 1012 {}
N 15978 76 15978 1076 {}
N 16180 76 16180 1076 {}
N 16382 76 16382 1076 {}
N 16498 0 16498 1076 {}
N 17104 0 17104 1076 {}
N 15690 0 15690 1140 {}
N 16296 0 16296 1140 {}
N 17190 76 17190 1140 {}
N 17392 76 17392 1140 {}
N 17594 76 17594 1140 {}
N 17710 0 17710 1140 {}
N 18316 0 18316 1140 {}
N 20336 0 20336 1140 {}
N 20942 0 20942 1140 {}
N 16584 -76 16584 -1972 {}
N 16786 -76 16786 -2036 {}
N 17796 -76 17796 -2100 {}
N 17998 -76 17998 -2164 {}
N 18402 76 18402 1204 {}
N 18604 76 18604 1204 {}
N 18806 76 18806 1204 {}
N 18922 0 18922 1204 {}
N 19528 0 19528 1204 {}
N 21548 0 21548 1204 {}
N 22154 0 22154 1204 {}
N 19008 -76 19008 -2228 {}
N 19210 -76 19210 -2292 {}
N 20220 -76 20220 -2356 {}
N 20422 -76 20422 -2420 {}
N 20538 0 20538 1268 {}
N 21144 0 21144 1268 {}
N 22038 76 22038 1268 {}
N 22240 76 22240 1268 {}
N 22442 76 22442 1268 {}
N 21432 -76 21432 -2484 {}
N 21634 -76 21634 -2548 {}
N 22644 -76 22644 -2612 {}
N 22846 -76 22846 -2676 {}
N 22760 0 22760 1332 {}
N 23366 0 23366 1332 {}
N 25386 0 25386 1332 {}
N 25992 0 25992 1332 {}
N 26886 76 26886 1332 {}
N 27088 76 27088 1332 {}
N 27290 76 27290 1332 {}
N 23250 76 23250 1396 {}
N 23452 76 23452 1396 {}
N 23654 76 23654 1396 {}
N 23770 0 23770 1396 {}
N 24376 0 24376 1396 {}
N 22962 0 22962 1460 {}
N 23568 0 23568 1460 {}
N 24462 76 24462 1460 {}
N 24664 76 24664 1460 {}
N 24866 76 24866 1460 {}
N 24982 0 24982 1460 {}
N 25588 0 25588 1460 {}
N 27608 0 27608 1460 {}
N 28214 0 28214 1460 {}
N 23856 -76 23856 -2740 {}
N 24058 -76 24058 -2804 {}
N 25068 -76 25068 -2868 {}
N 25270 -76 25270 -2932 {}
N 25674 76 25674 1524 {}
N 25876 76 25876 1524 {}
N 26078 76 26078 1524 {}
N 26194 0 26194 1524 {}
N 26800 0 26800 1524 {}
N 28820 0 28820 1524 {}
N 29426 0 29426 1524 {}
N 26280 -76 26280 -2996 {}
N 26482 -76 26482 -3060 {}
N 27492 -76 27492 -3124 {}
N 27694 -76 27694 -3188 {}
N 28098 76 28098 1588 {}
N 28300 76 28300 1588 {}
N 28502 76 28502 1588 {}
N 28618 0 28618 1588 {}
N 29224 0 29224 1588 {}
N 32860 0 32860 1588 {}
N 33466 0 33466 1588 {}
N 34072 0 34072 1588 {}
N 34678 0 34678 1588 {}
N 28704 -76 28704 -3252 {}
N 28906 -76 28906 -3316 {}
N 29916 -76 29916 -3380 {}
N 30234 0 30234 -3380 {}
N 30436 0 30436 -3380 {}
N 29830 0 29830 1652 {}
N 30032 0 30032 1652 {}
N 36698 0 36698 1652 {}
N 37304 0 37304 1652 {}
N 38198 76 38198 1652 {}
N 38400 76 38400 1652 {}
N 38602 76 38602 1652 {}
N 30320 -76 30320 -3444 {}
N 30638 0 30638 -3444 {}
N 30840 0 30840 -3444 {}
N 30724 -76 30724 -3508 {}
N 31042 0 31042 -3508 {}
N 31244 0 31244 -3508 {}
N 31128 -76 31128 -3572 {}
N 35486 0 35486 -3572 {}
N 36092 0 36092 -3572 {}
N 31532 -76 31532 -3636 {}
N 31734 -76 31734 -3700 {}
N 31648 0 31648 1716 {}
N 32254 0 32254 1716 {}
N 34274 0 34274 1716 {}
N 34880 0 34880 1716 {}
N 35774 76 35774 1716 {}
N 35976 76 35976 1716 {}
N 36178 76 36178 1716 {}
N 32138 76 32138 1780 {}
N 32340 76 32340 1780 {}
N 32542 76 32542 1780 {}
N 32658 0 32658 1780 {}
N 33264 0 33264 1780 {}
N 31850 0 31850 1844 {}
N 32456 0 32456 1844 {}
N 33350 76 33350 1844 {}
N 33552 76 33552 1844 {}
N 33754 76 33754 1844 {}
N 33870 0 33870 1844 {}
N 34476 0 34476 1844 {}
N 36496 0 36496 1844 {}
N 37102 0 37102 1844 {}
N 32744 -76 32744 -3764 {}
N 32946 -76 32946 -3828 {}
N 33956 -76 33956 -3892 {}
N 34158 -76 34158 -3956 {}
N 34562 76 34562 1908 {}
N 34764 76 34764 1908 {}
N 34966 76 34966 1908 {}
N 35082 0 35082 1908 {}
N 35688 0 35688 1908 {}
N 37708 0 37708 1908 {}
N 38314 0 38314 1908 {}
N 35168 -76 35168 -4020 {}
N 35370 -76 35370 -4084 {}
N 36380 -76 36380 -4148 {}
N 36582 -76 36582 -4212 {}
N 36986 76 36986 1972 {}
N 37188 76 37188 1972 {}
N 37390 76 37390 1972 {}
N 37506 0 37506 1972 {}
N 38112 0 38112 1972 {}
N 37592 -76 37592 -4276 {}
N 37794 -76 37794 -4340 {}
N 222 76 256 76 {}
N 256 76 256 -116 {}
N 14564 -76 14598 -76 {}
N 14598 -76 14598 116 {}
N 424 76 458 76 {}
N 458 76 458 -180 {}
N 29108 -76 29142 -76 {}
N 29142 -76 29142 180 {}
N 424 -76 390 -76 {}
N 390 -76 390 244 {}
N 1434 76 1468 76 {}
N 1468 76 1468 -244 {}
N 1838 76 1872 76 {}
N 1872 76 1872 -308 {}
N 13352 -76 13386 -76 {}
N 13386 -76 13386 308 {}
N 2040 76 2074 76 {}
N 2074 76 2074 -372 {}
N 20624 -76 20658 -76 {}
N 20658 -76 20658 372 {}
N 2040 -76 2006 -76 {}
N 2006 -76 2006 436 {}
N 3050 76 3084 76 {}
N 3084 76 3084 -436 {}
N 3454 76 3488 76 {}
N 3488 76 3488 -500 {}
N 3656 76 3690 76 {}
N 3690 76 3690 -564 {}
N 3656 -76 3622 -76 {}
N 3622 -76 3622 500 {}
N 4666 76 4700 76 {}
N 4700 76 4700 -628 {}
N 4868 76 4902 76 {}
N 4902 76 4902 -692 {}
N 4868 -76 4834 -76 {}
N 4834 -76 4834 564 {}
N 5878 76 5912 76 {}
N 5912 76 5912 -756 {}
N 6080 76 6114 76 {}
N 6114 76 6114 -820 {}
N 6080 -76 6046 -76 {}
N 6046 -76 6046 628 {}
N 7090 76 7124 76 {}
N 7124 76 7124 -884 {}
N 7292 76 7326 76 {}
N 7326 76 7326 -948 {}
N 7292 -76 7258 -76 {}
N 7258 -76 7258 692 {}
N 8302 76 8336 76 {}
N 8336 76 8336 -1012 {}
N 8504 76 8538 76 {}
N 8538 76 8538 -1076 {}
N 12140 -76 12174 -76 {}
N 12174 -76 12174 756 {}
N 8504 -76 8470 -76 {}
N 8470 -76 8470 820 {}
N 9716 -76 9750 -76 {}
N 9750 -76 9750 884 {}
N 9514 76 9548 76 {}
N 9548 76 9548 -1140 {}
N 9716 76 9682 76 {}
N 9682 76 9682 -1204 {}
N 10726 76 10760 76 {}
N 10760 76 10760 -1332 {}
N 10928 76 10962 76 {}
N 10962 76 10962 -1396 {}
N 10928 -76 10894 -76 {}
N 10894 -76 10894 948 {}
N 11938 76 11972 76 {}
N 11972 76 11972 -1460 {}
N 12140 76 12106 76 {}
N 12106 76 12106 -1524 {}
N 13150 76 13184 76 {}
N 13184 76 13184 -1588 {}
N 13352 76 13318 76 {}
N 13318 76 13318 -1652 {}
N 14362 76 14396 76 {}
N 14396 76 14396 -1716 {}
N 14564 76 14530 76 {}
N 14530 76 14530 -1780 {}
N 15574 76 15608 76 {}
N 15608 76 15608 -1844 {}
N 15776 76 15810 76 {}
N 15810 76 15810 -1908 {}
N 19412 -76 19446 -76 {}
N 19446 -76 19446 1012 {}
N 15776 -76 15742 -76 {}
N 15742 -76 15742 1076 {}
N 16988 -76 17022 -76 {}
N 17022 -76 17022 1140 {}
N 16786 76 16820 76 {}
N 16820 76 16820 -1972 {}
N 16988 76 16954 76 {}
N 16954 76 16954 -2036 {}
N 17998 76 18032 76 {}
N 18032 76 18032 -2100 {}
N 18200 76 18234 76 {}
N 18234 76 18234 -2164 {}
N 18200 -76 18166 -76 {}
N 18166 -76 18166 1204 {}
N 19210 76 19244 76 {}
N 19244 76 19244 -2228 {}
N 19412 76 19378 76 {}
N 19378 76 19378 -2292 {}
N 20422 76 20456 76 {}
N 20456 76 20456 -2356 {}
N 20624 76 20590 76 {}
N 20590 76 20590 -2420 {}
N 21836 -76 21870 -76 {}
N 21870 -76 21870 1268 {}
N 21634 76 21668 76 {}
N 21668 76 21668 -2484 {}
N 21836 76 21802 76 {}
N 21802 76 21802 -2548 {}
N 22846 76 22880 76 {}
N 22880 76 22880 -2612 {}
N 23048 76 23082 76 {}
N 23082 76 23082 -2676 {}
N 26684 -76 26718 -76 {}
N 26718 -76 26718 1332 {}
N 23048 -76 23014 -76 {}
N 23014 -76 23014 1396 {}
N 24260 -76 24294 -76 {}
N 24294 -76 24294 1460 {}
N 24058 76 24092 76 {}
N 24092 76 24092 -2740 {}
N 24260 76 24226 76 {}
N 24226 76 24226 -2804 {}
N 25270 76 25304 76 {}
N 25304 76 25304 -2868 {}
N 25472 76 25506 76 {}
N 25506 76 25506 -2932 {}
N 25472 -76 25438 -76 {}
N 25438 -76 25438 1524 {}
N 26482 76 26516 76 {}
N 26516 76 26516 -2996 {}
N 26684 76 26650 76 {}
N 26650 76 26650 -3060 {}
N 27694 76 27728 76 {}
N 27728 76 27728 -3124 {}
N 27896 76 27930 76 {}
N 27930 76 27930 -3188 {}
N 27896 -76 27862 -76 {}
N 27862 -76 27862 1588 {}
N 28906 76 28940 76 {}
N 28940 76 28940 -3252 {}
N 29108 76 29074 76 {}
N 29074 76 29074 -3316 {}
N 30118 76 30152 76 {}
N 30152 76 30152 -3380 {}
N 37996 -76 38030 -76 {}
N 38030 -76 38030 1652 {}
N 30522 76 30556 76 {}
N 30556 76 30556 -3444 {}
N 30926 76 30960 76 {}
N 30960 76 30960 -3508 {}
N 31330 76 31364 76 {}
N 31364 76 31364 -3572 {}
N 31734 76 31768 76 {}
N 31768 76 31768 -3636 {}
N 31936 76 31970 76 {}
N 31970 76 31970 -3700 {}
N 35572 -76 35606 -76 {}
N 35606 -76 35606 1716 {}
N 31936 -76 31902 -76 {}
N 31902 -76 31902 1780 {}
N 33148 -76 33182 -76 {}
N 33182 -76 33182 1844 {}
N 32946 76 32980 76 {}
N 32980 76 32980 -3764 {}
N 33148 76 33114 76 {}
N 33114 76 33114 -3828 {}
N 34158 76 34192 76 {}
N 34192 76 34192 -3892 {}
N 34360 76 34394 76 {}
N 34394 76 34394 -3956 {}
N 34360 -76 34326 -76 {}
N 34326 -76 34326 1908 {}
N 35370 76 35404 76 {}
N 35404 76 35404 -4020 {}
N 35572 76 35538 76 {}
N 35538 76 35538 -4084 {}
N 36582 76 36616 76 {}
N 36616 76 36616 -4148 {}
N 36784 76 36818 76 {}
N 36818 76 36818 -4212 {}
N 36784 -76 36750 -76 {}
N 36750 -76 36750 1972 {}
N 37794 76 37828 76 {}
N 37828 76 37828 -4276 {}
N 37996 76 37962 76 {}
N 37962 76 37962 -4340 {}
C {devices/ipin.sym} -300 -4444 0 0 {name=ip1 lab=VDD}
C {devices/ipin.sym} -300 2076 0 0 {name=ip2 lab=VSS}
C {devices/opin.sym} -300 -1268 0 0 {name=op3 lab=PLL_CLK}
C {devices/opin.sym} -300 1972 0 0 {name=op4 lab=FBCLK}
N 4 -116 288 -116 {}
N -82 116 15186 116 {}
N -316 2076 38058 2076 {lab=VSS}
N 206 -180 490 -180 {}
N 120 180 29730 180 {}
N 374 244 1364 244 {}
N -316 -4444 38664 -4444 {lab=VDD}
N 1216 -244 12676 -244 {}
N 1620 -308 1904 -308 {}
N 1534 308 14696 308 {}
N 1822 -372 2106 -372 {}
N 1736 372 21968 372 {}
N 1990 436 2980 436 {}
N 2832 -436 27220 -436 {}
N 3236 -500 3520 -500 {}
N 3438 -564 3722 -564 {}
N 3606 500 6414 500 {}
N 4448 -628 4732 -628 {}
N 4650 -692 4934 -692 {}
N 4818 564 7424 564 {}
N 5660 -756 5944 -756 {}
N 5862 -820 6146 -820 {}
N 6030 628 7626 628 {}
N 6872 -884 7156 -884 {}
N 7074 -948 7358 -948 {}
N 7242 692 19948 692 {}
N 8084 -1012 8368 -1012 {}
N 8286 -1076 8570 -1076 {}
N 8200 756 12762 756 {}
N 8454 820 9848 820 {}
N 8402 884 13686 884 {}
N 9296 -1140 9580 -1140 {}
N 9498 -1204 9698 -1204 {}
N -316 -1268 25806 -1268 {}
N 10508 -1332 10792 -1332 {}
N 10710 -1396 10994 -1396 {}
N 10878 948 14898 948 {}
N 11720 -1460 12004 -1460 {}
N 11922 -1524 12122 -1524 {}
N 12932 -1588 13216 -1588 {}
N 13134 -1652 13334 -1652 {}
N 14144 -1716 14428 -1716 {}
N 14346 -1780 14546 -1780 {}
N 15356 -1844 15640 -1844 {}
N 15558 -1908 15842 -1908 {}
N 15472 1012 20034 1012 {}
N 15726 1076 17120 1076 {}
N 15674 1140 20958 1140 {}
N 16568 -1972 16852 -1972 {}
N 16770 -2036 16970 -2036 {}
N 17780 -2100 18064 -2100 {}
N 17982 -2164 18266 -2164 {}
N 18150 1204 22170 1204 {}
N 18992 -2228 19276 -2228 {}
N 19194 -2292 19394 -2292 {}
N 20204 -2356 20488 -2356 {}
N 20406 -2420 20606 -2420 {}
N 20522 1268 22458 1268 {}
N 21416 -2484 21700 -2484 {}
N 21618 -2548 21818 -2548 {}
N 22628 -2612 22912 -2612 {}
N 22830 -2676 23114 -2676 {}
N 22744 1332 27306 1332 {}
N 22998 1396 24392 1396 {}
N 22946 1460 28230 1460 {}
N 23840 -2740 24124 -2740 {}
N 24042 -2804 24242 -2804 {}
N 25052 -2868 25336 -2868 {}
N 25254 -2932 25538 -2932 {}
N 25422 1524 29442 1524 {}
N 26264 -2996 26548 -2996 {}
N 26466 -3060 26666 -3060 {}
N 27476 -3124 27760 -3124 {}
N 27678 -3188 27962 -3188 {}
N 27846 1588 34694 1588 {}
N 28688 -3252 28972 -3252 {}
N 28890 -3316 29090 -3316 {}
N 29900 -3380 30452 -3380 {}
N 29814 1652 38618 1652 {}
N 30304 -3444 30856 -3444 {}
N 30708 -3508 31260 -3508 {}
N 31112 -3572 36108 -3572 {}
N 31516 -3636 31800 -3636 {}
N 31718 -3700 32002 -3700 {}
N 31632 1716 36194 1716 {}
N 31886 1780 33280 1780 {}
N 31834 1844 37118 1844 {}
N 32728 -3764 33012 -3764 {}
N 32930 -3828 33130 -3828 {}
N 33940 -3892 34224 -3892 {}
N 34142 -3956 34426 -3956 {}
N 34310 1908 38330 1908 {}
N 35152 -4020 35436 -4020 {}
N 35354 -4084 35554 -4084 {}
N 36364 -4148 36648 -4148 {}
N 36566 -4212 36850 -4212 {}
N -316 1972 38128 1972 {}
N 37576 -4276 37860 -4276 {}
N 37778 -4340 37978 -4340 {}
