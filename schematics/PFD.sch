v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {PFD   (auto · no-stub)} -300 -680 0 0 0.4 0.4 {layer=4}
C {sky130_fd_pr/nfet_01v8.sym} 0 0 0 0 {name=Xdref_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 20 -30 20 -76 {}
N -20 0 -66 0 {}
N 20 30 20 76 {}
N 20 0 66 0 {}
T {Xdref_g1N0} -16 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 202 0 0 0 {name=Xdref_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 222 -30 222 -76 {}
N 182 0 136 0 {}
N 222 30 222 76 {}
N 222 0 268 0 {}
T {Xdref_g1N1} 186 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 404 0 0 0 {name=Xdref_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 424 -30 424 -76 {}
N 384 0 338 0 {}
N 424 30 424 76 {}
N 424 0 470 0 {}
T {Xdref_g1N2} 388 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 606 0 0 0 {name=Xdref_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 626 30 626 76 {}
N 586 0 540 0 {}
N 626 -30 626 -76 {}
N 626 0 672 0 {}
T {Xdref_g1P0} 590 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 808 0 0 0 {name=Xdref_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 828 30 828 76 {}
N 788 0 742 0 {}
N 828 -30 828 -76 {}
N 828 0 874 0 {}
T {Xdref_g1P1} 792 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 1010 0 0 0 {name=Xdref_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 1030 30 1030 76 {}
N 990 0 944 0 {}
N 1030 -30 1030 -76 {}
N 1030 0 1076 0 {}
T {Xdref_g1P2} 994 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1212 0 0 0 {name=Xdref_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1232 -30 1232 -76 {}
N 1192 0 1146 0 {}
N 1232 30 1232 76 {}
N 1232 0 1278 0 {}
T {Xdref_g2N0} 1196 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1414 0 0 0 {name=Xdref_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1434 -30 1434 -76 {}
N 1394 0 1348 0 {}
N 1434 30 1434 76 {}
N 1434 0 1480 0 {}
T {Xdref_g2N1} 1398 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1616 0 0 0 {name=Xdref_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1636 -30 1636 -76 {}
N 1596 0 1550 0 {}
N 1636 30 1636 76 {}
N 1636 0 1682 0 {}
T {Xdref_g2N2} 1600 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 1818 0 0 0 {name=Xdref_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 1838 30 1838 76 {}
N 1798 0 1752 0 {}
N 1838 -30 1838 -76 {}
N 1838 0 1884 0 {}
T {Xdref_g2P0} 1802 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2020 0 0 0 {name=Xdref_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2040 30 2040 76 {}
N 2000 0 1954 0 {}
N 2040 -30 2040 -76 {}
N 2040 0 2086 0 {}
T {Xdref_g2P1} 2004 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2222 0 0 0 {name=Xdref_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2242 30 2242 76 {}
N 2202 0 2156 0 {}
N 2242 -30 2242 -76 {}
N 2242 0 2288 0 {}
T {Xdref_g2P2} 2206 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 2424 0 0 0 {name=Xdref_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 2444 -30 2444 -76 {}
N 2404 0 2358 0 {}
N 2444 30 2444 76 {}
N 2444 0 2490 0 {}
T {Xdref_g3N0} 2408 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 2626 0 0 0 {name=Xdref_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 2646 -30 2646 -76 {}
N 2606 0 2560 0 {}
N 2646 30 2646 76 {}
N 2646 0 2692 0 {}
T {Xdref_g3N1} 2610 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 2828 0 0 0 {name=Xdref_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 2848 -30 2848 -76 {}
N 2808 0 2762 0 {}
N 2848 30 2848 76 {}
N 2848 0 2894 0 {}
T {Xdref_g3N2} 2812 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3030 0 0 0 {name=Xdref_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3050 30 3050 76 {}
N 3010 0 2964 0 {}
N 3050 -30 3050 -76 {}
N 3050 0 3096 0 {}
T {Xdref_g3P0} 3014 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3232 0 0 0 {name=Xdref_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3252 30 3252 76 {}
N 3212 0 3166 0 {}
N 3252 -30 3252 -76 {}
N 3252 0 3298 0 {}
T {Xdref_g3P1} 3216 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3434 0 0 0 {name=Xdref_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3454 30 3454 76 {}
N 3414 0 3368 0 {}
N 3454 -30 3454 -76 {}
N 3454 0 3500 0 {}
T {Xdref_g3P2} 3418 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 3636 0 0 0 {name=Xdref_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 3656 -30 3656 -76 {}
N 3616 0 3570 0 {}
N 3656 30 3656 76 {}
N 3656 0 3702 0 {}
T {Xdref_g4N0} 3620 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 3838 0 0 0 {name=Xdref_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 3858 -30 3858 -76 {}
N 3818 0 3772 0 {}
N 3858 30 3858 76 {}
N 3858 0 3904 0 {}
T {Xdref_g4N1} 3822 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4040 0 0 0 {name=Xdref_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4060 -30 4060 -76 {}
N 4020 0 3974 0 {}
N 4060 30 4060 76 {}
N 4060 0 4106 0 {}
T {Xdref_g4N2} 4024 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 4242 0 0 0 {name=Xdref_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 4262 30 4262 76 {}
N 4222 0 4176 0 {}
N 4262 -30 4262 -76 {}
N 4262 0 4308 0 {}
T {Xdref_g4P0} 4226 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 4444 0 0 0 {name=Xdref_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 4464 30 4464 76 {}
N 4424 0 4378 0 {}
N 4464 -30 4464 -76 {}
N 4464 0 4510 0 {}
T {Xdref_g4P1} 4428 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 4646 0 0 0 {name=Xdref_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 4666 30 4666 76 {}
N 4626 0 4580 0 {}
N 4666 -30 4666 -76 {}
N 4666 0 4712 0 {}
T {Xdref_g4P2} 4630 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4848 0 0 0 {name=Xdref_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4868 -30 4868 -76 {}
N 4828 0 4782 0 {}
N 4868 30 4868 76 {}
N 4868 0 4914 0 {}
T {Xdref_g5N0} 4832 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 5050 0 0 0 {name=Xdref_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 5070 -30 5070 -76 {}
N 5030 0 4984 0 {}
N 5070 30 5070 76 {}
N 5070 0 5116 0 {}
T {Xdref_g5N1} 5034 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 5252 0 0 0 {name=Xdref_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 5272 -30 5272 -76 {}
N 5232 0 5186 0 {}
N 5272 30 5272 76 {}
N 5272 0 5318 0 {}
T {Xdref_g5N2} 5236 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5454 0 0 0 {name=Xdref_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5474 30 5474 76 {}
N 5434 0 5388 0 {}
N 5474 -30 5474 -76 {}
N 5474 0 5520 0 {}
T {Xdref_g5P0} 5438 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5656 0 0 0 {name=Xdref_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5676 30 5676 76 {}
N 5636 0 5590 0 {}
N 5676 -30 5676 -76 {}
N 5676 0 5722 0 {}
T {Xdref_g5P1} 5640 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5858 0 0 0 {name=Xdref_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5878 30 5878 76 {}
N 5838 0 5792 0 {}
N 5878 -30 5878 -76 {}
N 5878 0 5924 0 {}
T {Xdref_g5P2} 5842 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6060 0 0 0 {name=Xdref_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6080 -30 6080 -76 {}
N 6040 0 5994 0 {}
N 6080 30 6080 76 {}
N 6080 0 6126 0 {}
T {Xdref_g6N0} 6044 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6262 0 0 0 {name=Xdref_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6282 -30 6282 -76 {}
N 6242 0 6196 0 {}
N 6282 30 6282 76 {}
N 6282 0 6328 0 {}
T {Xdref_g6N1} 6246 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6464 0 0 0 {name=Xdref_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6484 -30 6484 -76 {}
N 6444 0 6398 0 {}
N 6484 30 6484 76 {}
N 6484 0 6530 0 {}
T {Xdref_g6N2} 6448 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 6666 0 0 0 {name=Xdref_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 6686 30 6686 76 {}
N 6646 0 6600 0 {}
N 6686 -30 6686 -76 {}
N 6686 0 6732 0 {}
T {Xdref_g6P0} 6650 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 6868 0 0 0 {name=Xdref_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 6888 30 6888 76 {}
N 6848 0 6802 0 {}
N 6888 -30 6888 -76 {}
N 6888 0 6934 0 {}
T {Xdref_g6P1} 6852 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7070 0 0 0 {name=Xdref_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7090 30 7090 76 {}
N 7050 0 7004 0 {}
N 7090 -30 7090 -76 {}
N 7090 0 7136 0 {}
T {Xdref_g6P2} 7054 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 7272 0 0 0 {name=Xdfb_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 7292 -30 7292 -76 {}
N 7252 0 7206 0 {}
N 7292 30 7292 76 {}
N 7292 0 7338 0 {}
T {Xdfb_g1N0} 7256 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 7474 0 0 0 {name=Xdfb_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 7494 -30 7494 -76 {}
N 7454 0 7408 0 {}
N 7494 30 7494 76 {}
N 7494 0 7540 0 {}
T {Xdfb_g1N1} 7458 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 7676 0 0 0 {name=Xdfb_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 7696 -30 7696 -76 {}
N 7656 0 7610 0 {}
N 7696 30 7696 76 {}
N 7696 0 7742 0 {}
T {Xdfb_g1N2} 7660 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7878 0 0 0 {name=Xdfb_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7898 30 7898 76 {}
N 7858 0 7812 0 {}
N 7898 -30 7898 -76 {}
N 7898 0 7944 0 {}
T {Xdfb_g1P0} 7862 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 8080 0 0 0 {name=Xdfb_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 8100 30 8100 76 {}
N 8060 0 8014 0 {}
N 8100 -30 8100 -76 {}
N 8100 0 8146 0 {}
T {Xdfb_g1P1} 8064 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 8282 0 0 0 {name=Xdfb_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 8302 30 8302 76 {}
N 8262 0 8216 0 {}
N 8302 -30 8302 -76 {}
N 8302 0 8348 0 {}
T {Xdfb_g1P2} 8266 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8484 0 0 0 {name=Xdfb_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8504 -30 8504 -76 {}
N 8464 0 8418 0 {}
N 8504 30 8504 76 {}
N 8504 0 8550 0 {}
T {Xdfb_g2N0} 8468 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8686 0 0 0 {name=Xdfb_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8706 -30 8706 -76 {}
N 8666 0 8620 0 {}
N 8706 30 8706 76 {}
N 8706 0 8752 0 {}
T {Xdfb_g2N1} 8670 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8888 0 0 0 {name=Xdfb_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8908 -30 8908 -76 {}
N 8868 0 8822 0 {}
N 8908 30 8908 76 {}
N 8908 0 8954 0 {}
T {Xdfb_g2N2} 8872 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9090 0 0 0 {name=Xdfb_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9110 30 9110 76 {}
N 9070 0 9024 0 {}
N 9110 -30 9110 -76 {}
N 9110 0 9156 0 {}
T {Xdfb_g2P0} 9074 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9292 0 0 0 {name=Xdfb_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9312 30 9312 76 {}
N 9272 0 9226 0 {}
N 9312 -30 9312 -76 {}
N 9312 0 9358 0 {}
T {Xdfb_g2P1} 9276 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9494 0 0 0 {name=Xdfb_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9514 30 9514 76 {}
N 9474 0 9428 0 {}
N 9514 -30 9514 -76 {}
N 9514 0 9560 0 {}
T {Xdfb_g2P2} 9478 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 9696 0 0 0 {name=Xdfb_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 9716 -30 9716 -76 {}
N 9676 0 9630 0 {}
N 9716 30 9716 76 {}
N 9716 0 9762 0 {}
T {Xdfb_g3N0} 9680 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 9898 0 0 0 {name=Xdfb_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 9918 -30 9918 -76 {}
N 9878 0 9832 0 {}
N 9918 30 9918 76 {}
N 9918 0 9964 0 {}
T {Xdfb_g3N1} 9882 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10100 0 0 0 {name=Xdfb_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10120 -30 10120 -76 {}
N 10080 0 10034 0 {}
N 10120 30 10120 76 {}
N 10120 0 10166 0 {}
T {Xdfb_g3N2} 10084 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 10302 0 0 0 {name=Xdfb_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 10322 30 10322 76 {}
N 10282 0 10236 0 {}
N 10322 -30 10322 -76 {}
N 10322 0 10368 0 {}
T {Xdfb_g3P0} 10286 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 10504 0 0 0 {name=Xdfb_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 10524 30 10524 76 {}
N 10484 0 10438 0 {}
N 10524 -30 10524 -76 {}
N 10524 0 10570 0 {}
T {Xdfb_g3P1} 10488 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 10706 0 0 0 {name=Xdfb_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 10726 30 10726 76 {}
N 10686 0 10640 0 {}
N 10726 -30 10726 -76 {}
N 10726 0 10772 0 {}
T {Xdfb_g3P2} 10690 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10908 0 0 0 {name=Xdfb_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10928 -30 10928 -76 {}
N 10888 0 10842 0 {}
N 10928 30 10928 76 {}
N 10928 0 10974 0 {}
T {Xdfb_g4N0} 10892 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 11110 0 0 0 {name=Xdfb_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 11130 -30 11130 -76 {}
N 11090 0 11044 0 {}
N 11130 30 11130 76 {}
N 11130 0 11176 0 {}
T {Xdfb_g4N1} 11094 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 11312 0 0 0 {name=Xdfb_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 11332 -30 11332 -76 {}
N 11292 0 11246 0 {}
N 11332 30 11332 76 {}
N 11332 0 11378 0 {}
T {Xdfb_g4N2} 11296 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11514 0 0 0 {name=Xdfb_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11534 30 11534 76 {}
N 11494 0 11448 0 {}
N 11534 -30 11534 -76 {}
N 11534 0 11580 0 {}
T {Xdfb_g4P0} 11498 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11716 0 0 0 {name=Xdfb_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11736 30 11736 76 {}
N 11696 0 11650 0 {}
N 11736 -30 11736 -76 {}
N 11736 0 11782 0 {}
T {Xdfb_g4P1} 11700 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11918 0 0 0 {name=Xdfb_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11938 30 11938 76 {}
N 11898 0 11852 0 {}
N 11938 -30 11938 -76 {}
N 11938 0 11984 0 {}
T {Xdfb_g4P2} 11902 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 12120 0 0 0 {name=Xdfb_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 12140 -30 12140 -76 {}
N 12100 0 12054 0 {}
N 12140 30 12140 76 {}
N 12140 0 12186 0 {}
T {Xdfb_g5N0} 12104 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 12322 0 0 0 {name=Xdfb_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 12342 -30 12342 -76 {}
N 12302 0 12256 0 {}
N 12342 30 12342 76 {}
N 12342 0 12388 0 {}
T {Xdfb_g5N1} 12306 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 12524 0 0 0 {name=Xdfb_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 12544 -30 12544 -76 {}
N 12504 0 12458 0 {}
N 12544 30 12544 76 {}
N 12544 0 12590 0 {}
T {Xdfb_g5N2} 12508 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12726 0 0 0 {name=Xdfb_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12746 30 12746 76 {}
N 12706 0 12660 0 {}
N 12746 -30 12746 -76 {}
N 12746 0 12792 0 {}
T {Xdfb_g5P0} 12710 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12928 0 0 0 {name=Xdfb_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12948 30 12948 76 {}
N 12908 0 12862 0 {}
N 12948 -30 12948 -76 {}
N 12948 0 12994 0 {}
T {Xdfb_g5P1} 12912 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13130 0 0 0 {name=Xdfb_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13150 30 13150 76 {}
N 13110 0 13064 0 {}
N 13150 -30 13150 -76 {}
N 13150 0 13196 0 {}
T {Xdfb_g5P2} 13114 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 13332 0 0 0 {name=Xdfb_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 13352 -30 13352 -76 {}
N 13312 0 13266 0 {}
N 13352 30 13352 76 {}
N 13352 0 13398 0 {}
T {Xdfb_g6N0} 13316 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 13534 0 0 0 {name=Xdfb_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 13554 -30 13554 -76 {}
N 13514 0 13468 0 {}
N 13554 30 13554 76 {}
N 13554 0 13600 0 {}
T {Xdfb_g6N1} 13518 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 13736 0 0 0 {name=Xdfb_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 13756 -30 13756 -76 {}
N 13716 0 13670 0 {}
N 13756 30 13756 76 {}
N 13756 0 13802 0 {}
T {Xdfb_g6N2} 13720 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13938 0 0 0 {name=Xdfb_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13958 30 13958 76 {}
N 13918 0 13872 0 {}
N 13958 -30 13958 -76 {}
N 13958 0 14004 0 {}
T {Xdfb_g6P0} 13922 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 14140 0 0 0 {name=Xdfb_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 14160 30 14160 76 {}
N 14120 0 14074 0 {}
N 14160 -30 14160 -76 {}
N 14160 0 14206 0 {}
T {Xdfb_g6P1} 14124 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 14342 0 0 0 {name=Xdfb_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 14362 30 14362 76 {}
N 14322 0 14276 0 {}
N 14362 -30 14362 -76 {}
N 14362 0 14408 0 {}
T {Xdfb_g6P2} 14326 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14544 0 0 0 {name=Xrst_N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14564 -30 14564 -76 {}
N 14524 0 14478 0 {}
N 14564 30 14564 76 {}
N 14564 0 14610 0 {}
T {Xrst_N0} 14528 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14746 0 0 0 {name=Xrst_N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14766 -30 14766 -76 {}
N 14726 0 14680 0 {}
N 14766 30 14766 76 {}
N 14766 0 14812 0 {}
T {Xrst_N1} 14730 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14948 0 0 0 {name=Xrst_N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14968 -30 14968 -76 {}
N 14928 0 14882 0 {}
N 14968 30 14968 76 {}
N 14968 0 15014 0 {}
T {Xrst_N2} 14932 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15150 0 0 0 {name=Xrst_P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15170 30 15170 76 {}
N 15130 0 15084 0 {}
N 15170 -30 15170 -76 {}
N 15170 0 15216 0 {}
T {Xrst_P0} 15134 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15352 0 0 0 {name=Xrst_P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15372 30 15372 76 {}
N 15332 0 15286 0 {}
N 15372 -30 15372 -76 {}
N 15372 0 15418 0 {}
T {Xrst_P1} 15336 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15554 0 0 0 {name=Xrst_P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15574 30 15574 76 {}
N 15534 0 15488 0 {}
N 15574 -30 15574 -76 {}
N 15574 0 15620 0 {}
T {Xrst_P2} 15538 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 15756 0 0 0 {name=Xinv1N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 15776 -30 15776 -76 {}
N 15736 0 15690 0 {}
N 15776 30 15776 76 {}
N 15776 0 15822 0 {}
T {Xinv1N} 15740 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15958 0 0 0 {name=Xinv1P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15978 30 15978 76 {}
N 15938 0 15892 0 {}
N 15978 -30 15978 -76 {}
N 15978 0 16024 0 {}
T {Xinv1P} 15942 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16160 0 0 0 {name=Xinv2N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16180 -30 16180 -76 {}
N 16140 0 16094 0 {}
N 16180 30 16180 76 {}
N 16180 0 16226 0 {}
T {Xinv2N} 16144 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 16362 0 0 0 {name=Xinv2P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 16382 30 16382 76 {}
N 16342 0 16296 0 {}
N 16382 -30 16382 -76 {}
N 16382 0 16428 0 {}
T {Xinv2P} 16346 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16564 0 0 0 {name=Xinv3N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16584 -30 16584 -76 {}
N 16544 0 16498 0 {}
N 16584 30 16584 76 {}
N 16584 0 16630 0 {}
T {Xinv3N} 16548 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 16766 0 0 0 {name=Xinv3P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 16786 30 16786 76 {}
N 16746 0 16700 0 {}
N 16786 -30 16786 -76 {}
N 16786 0 16832 0 {}
T {Xinv3P} 16750 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16968 0 0 0 {name=Xinv4N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16988 -30 16988 -76 {}
N 16948 0 16902 0 {}
N 16988 30 16988 76 {}
N 16988 0 17034 0 {}
T {Xinv4N} 16952 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17170 0 0 0 {name=Xinv4P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17190 30 17190 76 {}
N 17150 0 17104 0 {}
N 17190 -30 17190 -76 {}
N 17190 0 17236 0 {}
T {Xinv4P} 17154 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 17372 0 0 0 {name=XpgN1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 17392 -30 17392 -76 {}
N 17352 0 17306 0 {}
N 17392 30 17392 76 {}
N 17392 0 17438 0 {}
T {XpgN1} 17356 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 17574 0 0 0 {name=XpgN0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 17594 -30 17594 -76 {}
N 17554 0 17508 0 {}
N 17594 30 17594 76 {}
N 17594 0 17640 0 {}
T {XpgN0} 17558 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17776 0 0 0 {name=XpgP0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17796 30 17796 76 {}
N 17756 0 17710 0 {}
N 17796 -30 17796 -76 {}
N 17796 0 17842 0 {}
T {XpgP0} 17760 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17978 0 0 0 {name=XpgP1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17998 30 17998 76 {}
N 17958 0 17912 0 {}
N 17998 -30 17998 -76 {}
N 17998 0 18044 0 {}
T {XpgP1} 17962 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 18180 0 0 0 {name=XpginN
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 18200 -30 18200 -76 {}
N 18160 0 18114 0 {}
N 18200 30 18200 76 {}
N 18200 0 18246 0 {}
T {XpginN} 18164 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 18382 0 0 0 {name=XpginP
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 18402 30 18402 76 {}
N 18362 0 18316 0 {}
N 18402 -30 18402 -76 {}
N 18402 0 18448 0 {}
T {XpginP} 18366 76 0 0 0.11 0.11 {layer=13}
N 20 -76 20 -116 {}
N -66 0 -66 -2332 {}
N 540 0 540 -2332 {}
N 626 -76 626 -2332 {}
N 672 0 672 -2332 {}
N 828 -76 828 -2332 {}
N 874 0 874 -2332 {}
N 1030 -76 1030 -2332 {}
N 1076 0 1076 -2332 {}
N 1838 -76 1838 -2332 {}
N 1884 0 1884 -2332 {}
N 2040 -76 2040 -2332 {}
N 2086 0 2086 -2332 {}
N 2242 -76 2242 -2332 {}
N 2288 0 2288 -2332 {}
N 3050 -76 3050 -2332 {}
N 3096 0 3096 -2332 {}
N 3252 -76 3252 -2332 {}
N 3298 0 3298 -2332 {}
N 3454 -76 3454 -2332 {}
N 3500 0 3500 -2332 {}
N 3974 0 3974 -2332 {}
N 4262 -76 4262 -2332 {}
N 4308 0 4308 -2332 {}
N 4464 -76 4464 -2332 {}
N 4510 0 4510 -2332 {}
N 4580 0 4580 -2332 {}
N 4666 -76 4666 -2332 {}
N 4712 0 4712 -2332 {}
N 4782 0 4782 -2332 {}
N 5388 0 5388 -2332 {}
N 5474 -76 5474 -2332 {}
N 5520 0 5520 -2332 {}
N 5676 -76 5676 -2332 {}
N 5722 0 5722 -2332 {}
N 5878 -76 5878 -2332 {}
N 5924 0 5924 -2332 {}
N 6686 -76 6686 -2332 {}
N 6732 0 6732 -2332 {}
N 6888 -76 6888 -2332 {}
N 6934 0 6934 -2332 {}
N 7090 -76 7090 -2332 {}
N 7136 0 7136 -2332 {}
N 7206 0 7206 -2332 {}
N 7812 0 7812 -2332 {}
N 7898 -76 7898 -2332 {}
N 7944 0 7944 -2332 {}
N 8100 -76 8100 -2332 {}
N 8146 0 8146 -2332 {}
N 8302 -76 8302 -2332 {}
N 8348 0 8348 -2332 {}
N 9110 -76 9110 -2332 {}
N 9156 0 9156 -2332 {}
N 9312 -76 9312 -2332 {}
N 9358 0 9358 -2332 {}
N 9514 -76 9514 -2332 {}
N 9560 0 9560 -2332 {}
N 10322 -76 10322 -2332 {}
N 10368 0 10368 -2332 {}
N 10524 -76 10524 -2332 {}
N 10570 0 10570 -2332 {}
N 10726 -76 10726 -2332 {}
N 10772 0 10772 -2332 {}
N 11246 0 11246 -2332 {}
N 11534 -76 11534 -2332 {}
N 11580 0 11580 -2332 {}
N 11736 -76 11736 -2332 {}
N 11782 0 11782 -2332 {}
N 11852 0 11852 -2332 {}
N 11938 -76 11938 -2332 {}
N 11984 0 11984 -2332 {}
N 12054 0 12054 -2332 {}
N 12660 0 12660 -2332 {}
N 12746 -76 12746 -2332 {}
N 12792 0 12792 -2332 {}
N 12948 -76 12948 -2332 {}
N 12994 0 12994 -2332 {}
N 13150 -76 13150 -2332 {}
N 13196 0 13196 -2332 {}
N 13958 -76 13958 -2332 {}
N 14004 0 14004 -2332 {}
N 14160 -76 14160 -2332 {}
N 14206 0 14206 -2332 {}
N 14362 -76 14362 -2332 {}
N 14408 0 14408 -2332 {}
N 14882 0 14882 -2332 {}
N 15170 -76 15170 -2332 {}
N 15216 0 15216 -2332 {}
N 15372 -76 15372 -2332 {}
N 15418 0 15418 -2332 {}
N 15488 0 15488 -2332 {}
N 15574 -76 15574 -2332 {}
N 15620 0 15620 -2332 {}
N 15978 -76 15978 -2332 {}
N 16024 0 16024 -2332 {}
N 16382 -76 16382 -2332 {}
N 16428 0 16428 -2332 {}
N 16786 -76 16786 -2332 {}
N 16832 0 16832 -2332 {}
N 17190 -76 17190 -2332 {}
N 17236 0 17236 -2332 {}
N 17306 0 17306 -2332 {}
N 17796 -76 17796 -2332 {}
N 17842 0 17842 -2332 {}
N 17912 0 17912 -2332 {}
N 17998 -76 17998 -2332 {}
N 18044 0 18044 -2332 {}
N 18402 -76 18402 -2332 {}
N 18448 0 18448 -2332 {}
N 20 76 20 1052 {}
N 66 0 66 1052 {}
N 268 0 268 1052 {}
N 470 0 470 1052 {}
N 1232 76 1232 1052 {}
N 1278 0 1278 1052 {}
N 1480 0 1480 1052 {}
N 1682 0 1682 1052 {}
N 2444 76 2444 1052 {}
N 2490 0 2490 1052 {}
N 2692 0 2692 1052 {}
N 2894 0 2894 1052 {}
N 3656 76 3656 1052 {}
N 3702 0 3702 1052 {}
N 3904 0 3904 1052 {}
N 4106 0 4106 1052 {}
N 4868 76 4868 1052 {}
N 4914 0 4914 1052 {}
N 5116 0 5116 1052 {}
N 5318 0 5318 1052 {}
N 6080 76 6080 1052 {}
N 6126 0 6126 1052 {}
N 6328 0 6328 1052 {}
N 6530 0 6530 1052 {}
N 7292 76 7292 1052 {}
N 7338 0 7338 1052 {}
N 7540 0 7540 1052 {}
N 7742 0 7742 1052 {}
N 8504 76 8504 1052 {}
N 8550 0 8550 1052 {}
N 8752 0 8752 1052 {}
N 8954 0 8954 1052 {}
N 9716 76 9716 1052 {}
N 9762 0 9762 1052 {}
N 9964 0 9964 1052 {}
N 10166 0 10166 1052 {}
N 10928 76 10928 1052 {}
N 10974 0 10974 1052 {}
N 11176 0 11176 1052 {}
N 11378 0 11378 1052 {}
N 12140 76 12140 1052 {}
N 12186 0 12186 1052 {}
N 12388 0 12388 1052 {}
N 12590 0 12590 1052 {}
N 13352 76 13352 1052 {}
N 13398 0 13398 1052 {}
N 13600 0 13600 1052 {}
N 13802 0 13802 1052 {}
N 14564 76 14564 1052 {}
N 14610 0 14610 1052 {}
N 14812 0 14812 1052 {}
N 15014 0 15014 1052 {}
N 15776 76 15776 1052 {}
N 15822 0 15822 1052 {}
N 16180 76 16180 1052 {}
N 16226 0 16226 1052 {}
N 16584 76 16584 1052 {}
N 16630 0 16630 1052 {}
N 16988 76 16988 1052 {}
N 17034 0 17034 1052 {}
N 17438 0 17438 1052 {}
N 17594 76 17594 1052 {}
N 17640 0 17640 1052 {}
N 18200 76 18200 1052 {}
N 18246 0 18246 1052 {}
N 222 -76 222 -180 {}
N 136 0 136 116 {}
N 742 0 742 116 {}
N 2762 0 2762 116 {}
N 3368 0 3368 116 {}
N 4262 76 4262 116 {}
N 4464 76 4464 116 {}
N 4666 76 4666 116 {}
N 626 76 626 180 {}
N 828 76 828 180 {}
N 1030 76 1030 180 {}
N 1146 0 1146 180 {}
N 1752 0 1752 180 {}
N 338 0 338 244 {}
N 944 0 944 244 {}
N 1838 76 1838 244 {}
N 2040 76 2040 244 {}
N 2242 76 2242 244 {}
N 2358 0 2358 244 {}
N 2964 0 2964 244 {}
N 4984 0 4984 244 {}
N 5590 0 5590 244 {}
N 1232 -76 1232 -244 {}
N 1434 -76 1434 -308 {}
N 1348 0 1348 -372 {}
N 1954 0 1954 -372 {}
N 2560 0 2560 -372 {}
N 3166 0 3166 -372 {}
N 1550 0 1550 -436 {}
N 2156 0 2156 -436 {}
N 3772 0 3772 -436 {}
N 4378 0 4378 -436 {}
N 6398 0 6398 -436 {}
N 7004 0 7004 -436 {}
N 8822 0 8822 -436 {}
N 9428 0 9428 -436 {}
N 11044 0 11044 -436 {}
N 11650 0 11650 -436 {}
N 13670 0 13670 -436 {}
N 14276 0 14276 -436 {}
N 18200 -76 18200 -436 {}
N 2444 -76 2444 -500 {}
N 2646 -76 2646 -564 {}
N 3050 76 3050 308 {}
N 3252 76 3252 308 {}
N 3454 76 3454 308 {}
N 3570 0 3570 308 {}
N 4176 0 4176 308 {}
N 6196 0 6196 308 {}
N 6802 0 6802 308 {}
N 3656 -76 3656 -628 {}
N 3858 -76 3858 -692 {}
N 4868 -76 4868 -756 {}
N 5070 -76 5070 -820 {}
N 5474 76 5474 372 {}
N 5676 76 5676 372 {}
N 5878 76 5878 372 {}
N 5994 0 5994 372 {}
N 6600 0 6600 372 {}
N 14478 0 14478 372 {}
N 15084 0 15084 372 {}
N 5186 0 5186 436 {}
N 5792 0 5792 436 {}
N 6686 76 6686 436 {}
N 6888 76 6888 436 {}
N 7090 76 7090 436 {}
N 6080 -76 6080 -884 {}
N 6282 -76 6282 -948 {}
N 7292 -76 7292 -1012 {}
N 7494 -76 7494 -1076 {}
N 7408 0 7408 500 {}
N 8014 0 8014 500 {}
N 10034 0 10034 500 {}
N 10640 0 10640 500 {}
N 11534 76 11534 500 {}
N 11736 76 11736 500 {}
N 11938 76 11938 500 {}
N 7898 76 7898 564 {}
N 8100 76 8100 564 {}
N 8302 76 8302 564 {}
N 8418 0 8418 564 {}
N 9024 0 9024 564 {}
N 7610 0 7610 628 {}
N 8216 0 8216 628 {}
N 9110 76 9110 628 {}
N 9312 76 9312 628 {}
N 9514 76 9514 628 {}
N 9630 0 9630 628 {}
N 10236 0 10236 628 {}
N 12256 0 12256 628 {}
N 12862 0 12862 628 {}
N 8504 -76 8504 -1140 {}
N 8706 -76 8706 -1204 {}
N 8620 0 8620 -1268 {}
N 9226 0 9226 -1268 {}
N 9832 0 9832 -1268 {}
N 10438 0 10438 -1268 {}
N 9716 -76 9716 -1332 {}
N 9918 -76 9918 -1396 {}
N 10322 76 10322 692 {}
N 10524 76 10524 692 {}
N 10726 76 10726 692 {}
N 10842 0 10842 692 {}
N 11448 0 11448 692 {}
N 13468 0 13468 692 {}
N 14074 0 14074 692 {}
N 10928 -76 10928 -1460 {}
N 11130 -76 11130 -1524 {}
N 12140 -76 12140 -1588 {}
N 12342 -76 12342 -1652 {}
N 12746 76 12746 756 {}
N 12948 76 12948 756 {}
N 13150 76 13150 756 {}
N 13266 0 13266 756 {}
N 13872 0 13872 756 {}
N 14680 0 14680 756 {}
N 15286 0 15286 756 {}
N 12458 0 12458 820 {}
N 13064 0 13064 820 {}
N 13958 76 13958 820 {}
N 14160 76 14160 820 {}
N 14362 76 14362 820 {}
N 13352 -76 13352 -1716 {}
N 13554 -76 13554 -1780 {}
N 14564 -76 14564 -1844 {}
N 14766 -76 14766 -1908 {}
N 15170 76 15170 884 {}
N 15372 76 15372 884 {}
N 15574 76 15574 884 {}
N 15690 0 15690 884 {}
N 15892 0 15892 884 {}
N 15776 -76 15776 -1972 {}
N 16094 0 16094 -1972 {}
N 16296 0 16296 -1972 {}
N 16180 -76 16180 -2036 {}
N 16498 0 16498 -2036 {}
N 16700 0 16700 -2036 {}
N 16584 -76 16584 -2100 {}
N 16902 0 16902 -2100 {}
N 17104 0 17104 -2100 {}
N 16988 -76 16988 -2164 {}
N 17508 0 17508 -2164 {}
N 17710 0 17710 -2164 {}
N 17796 76 17796 948 {}
N 17998 76 17998 948 {}
N 18114 0 18114 948 {}
N 18316 0 18316 948 {}
N 17594 -76 17594 -2228 {}
N 222 76 256 76 {}
N 256 76 256 -116 {}
N 424 76 458 76 {}
N 458 76 458 -180 {}
N 4060 -76 4094 -76 {}
N 4094 -76 4094 116 {}
N 424 -76 390 -76 {}
N 390 -76 390 180 {}
N 1636 -76 1670 -76 {}
N 1670 -76 1670 244 {}
N 1434 76 1468 76 {}
N 1468 76 1468 -244 {}
N 1636 76 1602 76 {}
N 1602 76 1602 -308 {}
N 18402 76 18436 76 {}
N 18436 76 18436 -436 {}
N 2646 76 2680 76 {}
N 2680 76 2680 -500 {}
N 2848 76 2882 76 {}
N 2882 76 2882 -564 {}
N 2848 -76 2814 -76 {}
N 2814 -76 2814 308 {}
N 3858 76 3892 76 {}
N 3892 76 3892 -628 {}
N 4060 76 4026 76 {}
N 4026 76 4026 -692 {}
N 5070 76 5104 76 {}
N 5104 76 5104 -756 {}
N 5272 76 5306 76 {}
N 5306 76 5306 -820 {}
N 5272 -76 5238 -76 {}
N 5238 -76 5238 372 {}
N 6484 -76 6518 -76 {}
N 6518 -76 6518 436 {}
N 6282 76 6316 76 {}
N 6316 76 6316 -884 {}
N 6484 76 6450 76 {}
N 6450 76 6450 -948 {}
N 7494 76 7528 76 {}
N 7528 76 7528 -1012 {}
N 7696 76 7730 76 {}
N 7730 76 7730 -1076 {}
N 11332 -76 11366 -76 {}
N 11366 -76 11366 500 {}
N 7696 -76 7662 -76 {}
N 7662 -76 7662 564 {}
N 8908 -76 8942 -76 {}
N 8942 -76 8942 628 {}
N 8706 76 8740 76 {}
N 8740 76 8740 -1140 {}
N 8908 76 8874 76 {}
N 8874 76 8874 -1204 {}
N 9918 76 9952 76 {}
N 9952 76 9952 -1332 {}
N 10120 76 10154 76 {}
N 10154 76 10154 -1396 {}
N 10120 -76 10086 -76 {}
N 10086 -76 10086 692 {}
N 11130 76 11164 76 {}
N 11164 76 11164 -1460 {}
N 11332 76 11298 76 {}
N 11298 76 11298 -1524 {}
N 12342 76 12376 76 {}
N 12376 76 12376 -1588 {}
N 12544 76 12578 76 {}
N 12578 76 12578 -1652 {}
N 12544 -76 12510 -76 {}
N 12510 -76 12510 756 {}
N 13756 -76 13790 -76 {}
N 13790 -76 13790 820 {}
N 13554 76 13588 76 {}
N 13588 76 13588 -1716 {}
N 13756 76 13722 76 {}
N 13722 76 13722 -1780 {}
N 14766 76 14800 76 {}
N 14800 76 14800 -1844 {}
N 14968 76 15002 76 {}
N 15002 76 15002 -1908 {}
N 14968 -76 14934 -76 {}
N 14934 -76 14934 884 {}
N 15978 76 16012 76 {}
N 16012 76 16012 -1972 {}
N 16382 76 16416 76 {}
N 16416 76 16416 -2036 {}
N 16786 76 16820 76 {}
N 16820 76 16820 -2100 {}
N 17190 76 17224 76 {}
N 17224 76 17224 -2164 {}
N 17392 -76 17426 -76 {}
N 17426 -76 17426 948 {}
N 17392 76 17358 76 {}
N 17358 76 17358 -2228 {}
C {devices/ipin.sym} -300 -372 0 0 {name=ip1 lab=REFCLK}
C {devices/opin.sym} -300 -1268 0 0 {name=op2 lab=FBCLK}
C {devices/ipin.sym} -300 372 0 0 {name=ip3 lab=UP}
C {devices/ipin.sym} -300 756 0 0 {name=ip4 lab=DN}
C {devices/ipin.sym} -300 -2332 0 0 {name=ip5 lab=VDD}
C {devices/ipin.sym} -300 1052 0 0 {name=ip6 lab=VSS}
N 4 -116 288 -116 {}
N -316 -2332 18464 -2332 {lab=VDD}
N -316 1052 18262 1052 {lab=VSS}
N 206 -180 490 -180 {}
N 120 116 4682 116 {}
N 374 180 1768 180 {}
N 322 244 5606 244 {}
N 1216 -244 1500 -244 {}
N 1418 -308 1618 -308 {}
N -316 -372 3182 -372 {}
N 1534 -436 18468 -436 {}
N 2428 -500 2712 -500 {}
N 2630 -564 2914 -564 {}
N 2798 308 6818 308 {}
N 3640 -628 3924 -628 {}
N 3842 -692 4042 -692 {}
N 4852 -756 5136 -756 {}
N 5054 -820 5338 -820 {}
N -316 372 15100 372 {}
N 5170 436 7106 436 {}
N 6064 -884 6348 -884 {}
N 6266 -948 6466 -948 {}
N 7276 -1012 7560 -1012 {}
N 7478 -1076 7762 -1076 {}
N 7392 500 11954 500 {}
N 7646 564 9040 564 {}
N 7594 628 12878 628 {}
N 8488 -1140 8772 -1140 {}
N 8690 -1204 8890 -1204 {}
N -316 -1268 10454 -1268 {}
N 9700 -1332 9984 -1332 {}
N 9902 -1396 10186 -1396 {}
N 10070 692 14090 692 {}
N 10912 -1460 11196 -1460 {}
N 11114 -1524 11314 -1524 {}
N 12124 -1588 12408 -1588 {}
N 12326 -1652 12610 -1652 {}
N -316 756 15302 756 {}
N 12442 820 14378 820 {}
N 13336 -1716 13620 -1716 {}
N 13538 -1780 13738 -1780 {}
N 14548 -1844 14832 -1844 {}
N 14750 -1908 15034 -1908 {}
N 14918 884 15908 884 {}
N 15760 -1972 16312 -1972 {}
N 16164 -2036 16716 -2036 {}
N 16568 -2100 17120 -2100 {}
N 16972 -2164 17726 -2164 {}
N 17410 948 18332 948 {}
N 17342 -2228 17610 -2228 {}
