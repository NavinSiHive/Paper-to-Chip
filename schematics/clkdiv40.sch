v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {clkdiv40   (auto · no-stub)} -300 -680 0 0 0.4 0.4 {layer=4}
C {sky130_fd_pr/nfet_01v8.sym} 0 0 0 0 {name=Xs0_inv1N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 20 -30 20 -76 {}
N -20 0 -66 0 {}
N 20 30 20 76 {}
N 20 0 66 0 {}
T {Xs0_inv1N} -16 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 202 0 0 0 {name=Xs0_inv1P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 222 30 222 76 {}
N 182 0 136 0 {}
N 222 -30 222 -76 {}
N 222 0 268 0 {}
T {Xs0_inv1P} 186 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 404 0 0 0 {name=Xs0_inv2N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 424 -30 424 -76 {}
N 384 0 338 0 {}
N 424 30 424 76 {}
N 424 0 470 0 {}
T {Xs0_inv2N} 388 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 606 0 0 0 {name=Xs0_inv2P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 626 30 626 76 {}
N 586 0 540 0 {}
N 626 -30 626 -76 {}
N 626 0 672 0 {}
T {Xs0_inv2P} 590 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 808 0 0 0 {name=Xs0_inv3N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 828 -30 828 -76 {}
N 788 0 742 0 {}
N 828 30 828 76 {}
N 828 0 874 0 {}
T {Xs0_inv3N} 792 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 1010 0 0 0 {name=Xs0_inv3P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 1030 30 1030 76 {}
N 990 0 944 0 {}
N 1030 -30 1030 -76 {}
N 1030 0 1076 0 {}
T {Xs0_inv3P} 994 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1212 0 0 0 {name=Xs0_inv4N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1232 -30 1232 -76 {}
N 1192 0 1146 0 {}
N 1232 30 1232 76 {}
N 1232 0 1278 0 {}
T {Xs0_inv4N} 1196 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 1414 0 0 0 {name=Xs0_inv4P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 1434 30 1434 76 {}
N 1394 0 1348 0 {}
N 1434 -30 1434 -76 {}
N 1434 0 1480 0 {}
T {Xs0_inv4P} 1398 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1616 0 0 0 {name=Xs0_dff_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1636 -30 1636 -76 {}
N 1596 0 1550 0 {}
N 1636 30 1636 76 {}
N 1636 0 1682 0 {}
T {Xs0_dff_g1N0} 1600 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 1818 0 0 0 {name=Xs0_dff_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 1838 -30 1838 -76 {}
N 1798 0 1752 0 {}
N 1838 30 1838 76 {}
N 1838 0 1884 0 {}
T {Xs0_dff_g1N1} 1802 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 2020 0 0 0 {name=Xs0_dff_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 2040 -30 2040 -76 {}
N 2000 0 1954 0 {}
N 2040 30 2040 76 {}
N 2040 0 2086 0 {}
T {Xs0_dff_g1N2} 2004 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2222 0 0 0 {name=Xs0_dff_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2242 30 2242 76 {}
N 2202 0 2156 0 {}
N 2242 -30 2242 -76 {}
N 2242 0 2288 0 {}
T {Xs0_dff_g1P0} 2206 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2424 0 0 0 {name=Xs0_dff_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2444 30 2444 76 {}
N 2404 0 2358 0 {}
N 2444 -30 2444 -76 {}
N 2444 0 2490 0 {}
T {Xs0_dff_g1P1} 2408 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 2626 0 0 0 {name=Xs0_dff_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 2646 30 2646 76 {}
N 2606 0 2560 0 {}
N 2646 -30 2646 -76 {}
N 2646 0 2692 0 {}
T {Xs0_dff_g1P2} 2610 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 2828 0 0 0 {name=Xs0_dff_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 2848 -30 2848 -76 {}
N 2808 0 2762 0 {}
N 2848 30 2848 76 {}
N 2848 0 2894 0 {}
T {Xs0_dff_g2N0} 2812 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 3030 0 0 0 {name=Xs0_dff_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 3050 -30 3050 -76 {}
N 3010 0 2964 0 {}
N 3050 30 3050 76 {}
N 3050 0 3096 0 {}
T {Xs0_dff_g2N1} 3014 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 3232 0 0 0 {name=Xs0_dff_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 3252 -30 3252 -76 {}
N 3212 0 3166 0 {}
N 3252 30 3252 76 {}
N 3252 0 3298 0 {}
T {Xs0_dff_g2N2} 3216 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3434 0 0 0 {name=Xs0_dff_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3454 30 3454 76 {}
N 3414 0 3368 0 {}
N 3454 -30 3454 -76 {}
N 3454 0 3500 0 {}
T {Xs0_dff_g2P0} 3418 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3636 0 0 0 {name=Xs0_dff_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3656 30 3656 76 {}
N 3616 0 3570 0 {}
N 3656 -30 3656 -76 {}
N 3656 0 3702 0 {}
T {Xs0_dff_g2P1} 3620 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 3838 0 0 0 {name=Xs0_dff_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 3858 30 3858 76 {}
N 3818 0 3772 0 {}
N 3858 -30 3858 -76 {}
N 3858 0 3904 0 {}
T {Xs0_dff_g2P2} 3822 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4040 0 0 0 {name=Xs0_dff_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4060 -30 4060 -76 {}
N 4020 0 3974 0 {}
N 4060 30 4060 76 {}
N 4060 0 4106 0 {}
T {Xs0_dff_g3N0} 4024 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4242 0 0 0 {name=Xs0_dff_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4262 -30 4262 -76 {}
N 4222 0 4176 0 {}
N 4262 30 4262 76 {}
N 4262 0 4308 0 {}
T {Xs0_dff_g3N1} 4226 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 4444 0 0 0 {name=Xs0_dff_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 4464 -30 4464 -76 {}
N 4424 0 4378 0 {}
N 4464 30 4464 76 {}
N 4464 0 4510 0 {}
T {Xs0_dff_g3N2} 4428 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 4646 0 0 0 {name=Xs0_dff_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 4666 30 4666 76 {}
N 4626 0 4580 0 {}
N 4666 -30 4666 -76 {}
N 4666 0 4712 0 {}
T {Xs0_dff_g3P0} 4630 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 4848 0 0 0 {name=Xs0_dff_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 4868 30 4868 76 {}
N 4828 0 4782 0 {}
N 4868 -30 4868 -76 {}
N 4868 0 4914 0 {}
T {Xs0_dff_g3P1} 4832 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5050 0 0 0 {name=Xs0_dff_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5070 30 5070 76 {}
N 5030 0 4984 0 {}
N 5070 -30 5070 -76 {}
N 5070 0 5116 0 {}
T {Xs0_dff_g3P2} 5034 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 5252 0 0 0 {name=Xs0_dff_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 5272 -30 5272 -76 {}
N 5232 0 5186 0 {}
N 5272 30 5272 76 {}
N 5272 0 5318 0 {}
T {Xs0_dff_g4N0} 5236 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 5454 0 0 0 {name=Xs0_dff_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 5474 -30 5474 -76 {}
N 5434 0 5388 0 {}
N 5474 30 5474 76 {}
N 5474 0 5520 0 {}
T {Xs0_dff_g4N1} 5438 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 5656 0 0 0 {name=Xs0_dff_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 5676 -30 5676 -76 {}
N 5636 0 5590 0 {}
N 5676 30 5676 76 {}
N 5676 0 5722 0 {}
T {Xs0_dff_g4N2} 5640 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 5858 0 0 0 {name=Xs0_dff_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 5878 30 5878 76 {}
N 5838 0 5792 0 {}
N 5878 -30 5878 -76 {}
N 5878 0 5924 0 {}
T {Xs0_dff_g4P0} 5842 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 6060 0 0 0 {name=Xs0_dff_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 6080 30 6080 76 {}
N 6040 0 5994 0 {}
N 6080 -30 6080 -76 {}
N 6080 0 6126 0 {}
T {Xs0_dff_g4P1} 6044 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 6262 0 0 0 {name=Xs0_dff_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 6282 30 6282 76 {}
N 6242 0 6196 0 {}
N 6282 -30 6282 -76 {}
N 6282 0 6328 0 {}
T {Xs0_dff_g4P2} 6246 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6464 0 0 0 {name=Xs0_dff_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6484 -30 6484 -76 {}
N 6444 0 6398 0 {}
N 6484 30 6484 76 {}
N 6484 0 6530 0 {}
T {Xs0_dff_g5N0} 6448 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6666 0 0 0 {name=Xs0_dff_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6686 -30 6686 -76 {}
N 6646 0 6600 0 {}
N 6686 30 6686 76 {}
N 6686 0 6732 0 {}
T {Xs0_dff_g5N1} 6650 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 6868 0 0 0 {name=Xs0_dff_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 6888 -30 6888 -76 {}
N 6848 0 6802 0 {}
N 6888 30 6888 76 {}
N 6888 0 6934 0 {}
T {Xs0_dff_g5N2} 6852 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7070 0 0 0 {name=Xs0_dff_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7090 30 7090 76 {}
N 7050 0 7004 0 {}
N 7090 -30 7090 -76 {}
N 7090 0 7136 0 {}
T {Xs0_dff_g5P0} 7054 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7272 0 0 0 {name=Xs0_dff_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7292 30 7292 76 {}
N 7252 0 7206 0 {}
N 7292 -30 7292 -76 {}
N 7292 0 7338 0 {}
T {Xs0_dff_g5P1} 7256 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 7474 0 0 0 {name=Xs0_dff_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 7494 30 7494 76 {}
N 7454 0 7408 0 {}
N 7494 -30 7494 -76 {}
N 7494 0 7540 0 {}
T {Xs0_dff_g5P2} 7458 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 7676 0 0 0 {name=Xs0_dff_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 7696 -30 7696 -76 {}
N 7656 0 7610 0 {}
N 7696 30 7696 76 {}
N 7696 0 7742 0 {}
T {Xs0_dff_g6N0} 7660 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 7878 0 0 0 {name=Xs0_dff_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 7898 -30 7898 -76 {}
N 7858 0 7812 0 {}
N 7898 30 7898 76 {}
N 7898 0 7944 0 {}
T {Xs0_dff_g6N1} 7862 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8080 0 0 0 {name=Xs0_dff_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8100 -30 8100 -76 {}
N 8060 0 8014 0 {}
N 8100 30 8100 76 {}
N 8100 0 8146 0 {}
T {Xs0_dff_g6N2} 8064 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 8282 0 0 0 {name=Xs0_dff_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 8302 30 8302 76 {}
N 8262 0 8216 0 {}
N 8302 -30 8302 -76 {}
N 8302 0 8348 0 {}
T {Xs0_dff_g6P0} 8266 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 8484 0 0 0 {name=Xs0_dff_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 8504 30 8504 76 {}
N 8464 0 8418 0 {}
N 8504 -30 8504 -76 {}
N 8504 0 8550 0 {}
T {Xs0_dff_g6P1} 8468 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 8686 0 0 0 {name=Xs0_dff_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 8706 30 8706 76 {}
N 8666 0 8620 0 {}
N 8706 -30 8706 -76 {}
N 8706 0 8752 0 {}
T {Xs0_dff_g6P2} 8670 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 8888 0 0 0 {name=Xs1_inv1N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 8908 -30 8908 -76 {}
N 8868 0 8822 0 {}
N 8908 30 8908 76 {}
N 8908 0 8954 0 {}
T {Xs1_inv1N} 8872 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9090 0 0 0 {name=Xs1_inv1P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9110 30 9110 76 {}
N 9070 0 9024 0 {}
N 9110 -30 9110 -76 {}
N 9110 0 9156 0 {}
T {Xs1_inv1P} 9074 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 9292 0 0 0 {name=Xs1_inv2N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 9312 -30 9312 -76 {}
N 9272 0 9226 0 {}
N 9312 30 9312 76 {}
N 9312 0 9358 0 {}
T {Xs1_inv2N} 9276 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9494 0 0 0 {name=Xs1_inv2P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9514 30 9514 76 {}
N 9474 0 9428 0 {}
N 9514 -30 9514 -76 {}
N 9514 0 9560 0 {}
T {Xs1_inv2P} 9478 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 9696 0 0 0 {name=Xs1_inv3N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 9716 -30 9716 -76 {}
N 9676 0 9630 0 {}
N 9716 30 9716 76 {}
N 9716 0 9762 0 {}
T {Xs1_inv3N} 9680 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 9898 0 0 0 {name=Xs1_inv3P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 9918 30 9918 76 {}
N 9878 0 9832 0 {}
N 9918 -30 9918 -76 {}
N 9918 0 9964 0 {}
T {Xs1_inv3P} 9882 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10100 0 0 0 {name=Xs1_inv4N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10120 -30 10120 -76 {}
N 10080 0 10034 0 {}
N 10120 30 10120 76 {}
N 10120 0 10166 0 {}
T {Xs1_inv4N} 10084 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 10302 0 0 0 {name=Xs1_inv4P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 10322 30 10322 76 {}
N 10282 0 10236 0 {}
N 10322 -30 10322 -76 {}
N 10322 0 10368 0 {}
T {Xs1_inv4P} 10286 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10504 0 0 0 {name=Xs1_dff_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10524 -30 10524 -76 {}
N 10484 0 10438 0 {}
N 10524 30 10524 76 {}
N 10524 0 10570 0 {}
T {Xs1_dff_g1N0} 10488 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10706 0 0 0 {name=Xs1_dff_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10726 -30 10726 -76 {}
N 10686 0 10640 0 {}
N 10726 30 10726 76 {}
N 10726 0 10772 0 {}
T {Xs1_dff_g1N1} 10690 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 10908 0 0 0 {name=Xs1_dff_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 10928 -30 10928 -76 {}
N 10888 0 10842 0 {}
N 10928 30 10928 76 {}
N 10928 0 10974 0 {}
T {Xs1_dff_g1N2} 10892 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11110 0 0 0 {name=Xs1_dff_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11130 30 11130 76 {}
N 11090 0 11044 0 {}
N 11130 -30 11130 -76 {}
N 11130 0 11176 0 {}
T {Xs1_dff_g1P0} 11094 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11312 0 0 0 {name=Xs1_dff_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11332 30 11332 76 {}
N 11292 0 11246 0 {}
N 11332 -30 11332 -76 {}
N 11332 0 11378 0 {}
T {Xs1_dff_g1P1} 11296 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 11514 0 0 0 {name=Xs1_dff_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 11534 30 11534 76 {}
N 11494 0 11448 0 {}
N 11534 -30 11534 -76 {}
N 11534 0 11580 0 {}
T {Xs1_dff_g1P2} 11498 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 11716 0 0 0 {name=Xs1_dff_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 11736 -30 11736 -76 {}
N 11696 0 11650 0 {}
N 11736 30 11736 76 {}
N 11736 0 11782 0 {}
T {Xs1_dff_g2N0} 11700 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 11918 0 0 0 {name=Xs1_dff_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 11938 -30 11938 -76 {}
N 11898 0 11852 0 {}
N 11938 30 11938 76 {}
N 11938 0 11984 0 {}
T {Xs1_dff_g2N1} 11902 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 12120 0 0 0 {name=Xs1_dff_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 12140 -30 12140 -76 {}
N 12100 0 12054 0 {}
N 12140 30 12140 76 {}
N 12140 0 12186 0 {}
T {Xs1_dff_g2N2} 12104 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12322 0 0 0 {name=Xs1_dff_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12342 30 12342 76 {}
N 12302 0 12256 0 {}
N 12342 -30 12342 -76 {}
N 12342 0 12388 0 {}
T {Xs1_dff_g2P0} 12306 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12524 0 0 0 {name=Xs1_dff_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12544 30 12544 76 {}
N 12504 0 12458 0 {}
N 12544 -30 12544 -76 {}
N 12544 0 12590 0 {}
T {Xs1_dff_g2P1} 12508 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 12726 0 0 0 {name=Xs1_dff_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 12746 30 12746 76 {}
N 12706 0 12660 0 {}
N 12746 -30 12746 -76 {}
N 12746 0 12792 0 {}
T {Xs1_dff_g2P2} 12710 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 12928 0 0 0 {name=Xs1_dff_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 12948 -30 12948 -76 {}
N 12908 0 12862 0 {}
N 12948 30 12948 76 {}
N 12948 0 12994 0 {}
T {Xs1_dff_g3N0} 12912 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 13130 0 0 0 {name=Xs1_dff_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 13150 -30 13150 -76 {}
N 13110 0 13064 0 {}
N 13150 30 13150 76 {}
N 13150 0 13196 0 {}
T {Xs1_dff_g3N1} 13114 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 13332 0 0 0 {name=Xs1_dff_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 13352 -30 13352 -76 {}
N 13312 0 13266 0 {}
N 13352 30 13352 76 {}
N 13352 0 13398 0 {}
T {Xs1_dff_g3N2} 13316 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13534 0 0 0 {name=Xs1_dff_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13554 30 13554 76 {}
N 13514 0 13468 0 {}
N 13554 -30 13554 -76 {}
N 13554 0 13600 0 {}
T {Xs1_dff_g3P0} 13518 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13736 0 0 0 {name=Xs1_dff_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13756 30 13756 76 {}
N 13716 0 13670 0 {}
N 13756 -30 13756 -76 {}
N 13756 0 13802 0 {}
T {Xs1_dff_g3P1} 13720 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 13938 0 0 0 {name=Xs1_dff_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 13958 30 13958 76 {}
N 13918 0 13872 0 {}
N 13958 -30 13958 -76 {}
N 13958 0 14004 0 {}
T {Xs1_dff_g3P2} 13922 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14140 0 0 0 {name=Xs1_dff_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14160 -30 14160 -76 {}
N 14120 0 14074 0 {}
N 14160 30 14160 76 {}
N 14160 0 14206 0 {}
T {Xs1_dff_g4N0} 14124 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14342 0 0 0 {name=Xs1_dff_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14362 -30 14362 -76 {}
N 14322 0 14276 0 {}
N 14362 30 14362 76 {}
N 14362 0 14408 0 {}
T {Xs1_dff_g4N1} 14326 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 14544 0 0 0 {name=Xs1_dff_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 14564 -30 14564 -76 {}
N 14524 0 14478 0 {}
N 14564 30 14564 76 {}
N 14564 0 14610 0 {}
T {Xs1_dff_g4N2} 14528 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 14746 0 0 0 {name=Xs1_dff_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 14766 30 14766 76 {}
N 14726 0 14680 0 {}
N 14766 -30 14766 -76 {}
N 14766 0 14812 0 {}
T {Xs1_dff_g4P0} 14730 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 14948 0 0 0 {name=Xs1_dff_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 14968 30 14968 76 {}
N 14928 0 14882 0 {}
N 14968 -30 14968 -76 {}
N 14968 0 15014 0 {}
T {Xs1_dff_g4P1} 14932 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15150 0 0 0 {name=Xs1_dff_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15170 30 15170 76 {}
N 15130 0 15084 0 {}
N 15170 -30 15170 -76 {}
N 15170 0 15216 0 {}
T {Xs1_dff_g4P2} 15134 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 15352 0 0 0 {name=Xs1_dff_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 15372 -30 15372 -76 {}
N 15332 0 15286 0 {}
N 15372 30 15372 76 {}
N 15372 0 15418 0 {}
T {Xs1_dff_g5N0} 15336 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 15554 0 0 0 {name=Xs1_dff_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 15574 -30 15574 -76 {}
N 15534 0 15488 0 {}
N 15574 30 15574 76 {}
N 15574 0 15620 0 {}
T {Xs1_dff_g5N1} 15538 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 15756 0 0 0 {name=Xs1_dff_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 15776 -30 15776 -76 {}
N 15736 0 15690 0 {}
N 15776 30 15776 76 {}
N 15776 0 15822 0 {}
T {Xs1_dff_g5N2} 15740 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 15958 0 0 0 {name=Xs1_dff_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 15978 30 15978 76 {}
N 15938 0 15892 0 {}
N 15978 -30 15978 -76 {}
N 15978 0 16024 0 {}
T {Xs1_dff_g5P0} 15942 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 16160 0 0 0 {name=Xs1_dff_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 16180 30 16180 76 {}
N 16140 0 16094 0 {}
N 16180 -30 16180 -76 {}
N 16180 0 16226 0 {}
T {Xs1_dff_g5P1} 16144 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 16362 0 0 0 {name=Xs1_dff_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 16382 30 16382 76 {}
N 16342 0 16296 0 {}
N 16382 -30 16382 -76 {}
N 16382 0 16428 0 {}
T {Xs1_dff_g5P2} 16346 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16564 0 0 0 {name=Xs1_dff_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16584 -30 16584 -76 {}
N 16544 0 16498 0 {}
N 16584 30 16584 76 {}
N 16584 0 16630 0 {}
T {Xs1_dff_g6N0} 16548 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16766 0 0 0 {name=Xs1_dff_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16786 -30 16786 -76 {}
N 16746 0 16700 0 {}
N 16786 30 16786 76 {}
N 16786 0 16832 0 {}
T {Xs1_dff_g6N1} 16750 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 16968 0 0 0 {name=Xs1_dff_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 16988 -30 16988 -76 {}
N 16948 0 16902 0 {}
N 16988 30 16988 76 {}
N 16988 0 17034 0 {}
T {Xs1_dff_g6N2} 16952 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17170 0 0 0 {name=Xs1_dff_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17190 30 17190 76 {}
N 17150 0 17104 0 {}
N 17190 -30 17190 -76 {}
N 17190 0 17236 0 {}
T {Xs1_dff_g6P0} 17154 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17372 0 0 0 {name=Xs1_dff_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17392 30 17392 76 {}
N 17352 0 17306 0 {}
N 17392 -30 17392 -76 {}
N 17392 0 17438 0 {}
T {Xs1_dff_g6P1} 17356 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 17574 0 0 0 {name=Xs1_dff_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 17594 30 17594 76 {}
N 17554 0 17508 0 {}
N 17594 -30 17594 -76 {}
N 17594 0 17640 0 {}
T {Xs1_dff_g6P2} 17558 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 17776 0 0 0 {name=Xd5_g0N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 17796 -30 17796 -76 {}
N 17756 0 17710 0 {}
N 17796 30 17796 76 {}
N 17796 0 17842 0 {}
T {Xd5_g0N0} 17760 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 17978 0 0 0 {name=Xd5_g0N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 17998 -30 17998 -76 {}
N 17958 0 17912 0 {}
N 17998 30 17998 76 {}
N 17998 0 18044 0 {}
T {Xd5_g0N1} 17962 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 18180 0 0 0 {name=Xd5_g0N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 18200 -30 18200 -76 {}
N 18160 0 18114 0 {}
N 18200 30 18200 76 {}
N 18200 0 18246 0 {}
T {Xd5_g0N2} 18164 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 18382 0 0 0 {name=Xd5_g0P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 18402 30 18402 76 {}
N 18362 0 18316 0 {}
N 18402 -30 18402 -76 {}
N 18402 0 18448 0 {}
T {Xd5_g0P0} 18366 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 18584 0 0 0 {name=Xd5_g0P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 18604 30 18604 76 {}
N 18564 0 18518 0 {}
N 18604 -30 18604 -76 {}
N 18604 0 18650 0 {}
T {Xd5_g0P1} 18568 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 18786 0 0 0 {name=Xd5_g0P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 18806 30 18806 76 {}
N 18766 0 18720 0 {}
N 18806 -30 18806 -76 {}
N 18806 0 18852 0 {}
T {Xd5_g0P2} 18770 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 18988 0 0 0 {name=Xd5_i0N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 19008 -30 19008 -76 {}
N 18968 0 18922 0 {}
N 19008 30 19008 76 {}
N 19008 0 19054 0 {}
T {Xd5_i0N} 18972 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 19190 0 0 0 {name=Xd5_i0P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 19210 30 19210 76 {}
N 19170 0 19124 0 {}
N 19210 -30 19210 -76 {}
N 19210 0 19256 0 {}
T {Xd5_i0P} 19174 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 19392 0 0 0 {name=Xd5_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 19412 -30 19412 -76 {}
N 19372 0 19326 0 {}
N 19412 30 19412 76 {}
N 19412 0 19458 0 {}
T {Xd5_g2N0} 19376 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 19594 0 0 0 {name=Xd5_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 19614 -30 19614 -76 {}
N 19574 0 19528 0 {}
N 19614 30 19614 76 {}
N 19614 0 19660 0 {}
T {Xd5_g2N1} 19578 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 19796 0 0 0 {name=Xd5_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 19816 -30 19816 -76 {}
N 19776 0 19730 0 {}
N 19816 30 19816 76 {}
N 19816 0 19862 0 {}
T {Xd5_g2N2} 19780 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 19998 0 0 0 {name=Xd5_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 20018 30 20018 76 {}
N 19978 0 19932 0 {}
N 20018 -30 20018 -76 {}
N 20018 0 20064 0 {}
T {Xd5_g2P0} 19982 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 20200 0 0 0 {name=Xd5_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 20220 30 20220 76 {}
N 20180 0 20134 0 {}
N 20220 -30 20220 -76 {}
N 20220 0 20266 0 {}
T {Xd5_g2P1} 20184 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 20402 0 0 0 {name=Xd5_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 20422 30 20422 76 {}
N 20382 0 20336 0 {}
N 20422 -30 20422 -76 {}
N 20422 0 20468 0 {}
T {Xd5_g2P2} 20386 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 20604 0 0 0 {name=Xd5_i2N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 20624 -30 20624 -76 {}
N 20584 0 20538 0 {}
N 20624 30 20624 76 {}
N 20624 0 20670 0 {}
T {Xd5_i2N} 20588 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 20806 0 0 0 {name=Xd5_i2P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 20826 30 20826 76 {}
N 20786 0 20740 0 {}
N 20826 -30 20826 -76 {}
N 20826 0 20872 0 {}
T {Xd5_i2P} 20790 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 21008 0 0 0 {name=Xd5_x1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 21028 -30 21028 -76 {}
N 20988 0 20942 0 {}
N 21028 30 21028 76 {}
N 21028 0 21074 0 {}
T {Xd5_x1N0} 20992 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 21210 0 0 0 {name=Xd5_x1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 21230 -30 21230 -76 {}
N 21190 0 21144 0 {}
N 21230 30 21230 76 {}
N 21230 0 21276 0 {}
T {Xd5_x1N1} 21194 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 21412 0 0 0 {name=Xd5_x1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 21432 -30 21432 -76 {}
N 21392 0 21346 0 {}
N 21432 30 21432 76 {}
N 21432 0 21478 0 {}
T {Xd5_x1N2} 21396 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 21614 0 0 0 {name=Xd5_x1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 21634 30 21634 76 {}
N 21594 0 21548 0 {}
N 21634 -30 21634 -76 {}
N 21634 0 21680 0 {}
T {Xd5_x1P0} 21598 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 21816 0 0 0 {name=Xd5_x1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 21836 30 21836 76 {}
N 21796 0 21750 0 {}
N 21836 -30 21836 -76 {}
N 21836 0 21882 0 {}
T {Xd5_x1P1} 21800 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 22018 0 0 0 {name=Xd5_x1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 22038 30 22038 76 {}
N 21998 0 21952 0 {}
N 22038 -30 22038 -76 {}
N 22038 0 22084 0 {}
T {Xd5_x1P2} 22002 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 22220 0 0 0 {name=Xd5_x2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 22240 -30 22240 -76 {}
N 22200 0 22154 0 {}
N 22240 30 22240 76 {}
N 22240 0 22286 0 {}
T {Xd5_x2N0} 22204 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 22422 0 0 0 {name=Xd5_x2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 22442 -30 22442 -76 {}
N 22402 0 22356 0 {}
N 22442 30 22442 76 {}
N 22442 0 22488 0 {}
T {Xd5_x2N1} 22406 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 22624 0 0 0 {name=Xd5_x2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 22644 -30 22644 -76 {}
N 22604 0 22558 0 {}
N 22644 30 22644 76 {}
N 22644 0 22690 0 {}
T {Xd5_x2N2} 22608 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 22826 0 0 0 {name=Xd5_x2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 22846 30 22846 76 {}
N 22806 0 22760 0 {}
N 22846 -30 22846 -76 {}
N 22846 0 22892 0 {}
T {Xd5_x2P0} 22810 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 23028 0 0 0 {name=Xd5_x2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 23048 30 23048 76 {}
N 23008 0 22962 0 {}
N 23048 -30 23048 -76 {}
N 23048 0 23094 0 {}
T {Xd5_x2P1} 23012 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 23230 0 0 0 {name=Xd5_x2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 23250 30 23250 76 {}
N 23210 0 23164 0 {}
N 23250 -30 23250 -76 {}
N 23250 0 23296 0 {}
T {Xd5_x2P2} 23214 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 23432 0 0 0 {name=Xd5_x3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 23452 -30 23452 -76 {}
N 23412 0 23366 0 {}
N 23452 30 23452 76 {}
N 23452 0 23498 0 {}
T {Xd5_x3N0} 23416 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 23634 0 0 0 {name=Xd5_x3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 23654 -30 23654 -76 {}
N 23614 0 23568 0 {}
N 23654 30 23654 76 {}
N 23654 0 23700 0 {}
T {Xd5_x3N1} 23618 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 23836 0 0 0 {name=Xd5_x3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 23856 -30 23856 -76 {}
N 23816 0 23770 0 {}
N 23856 30 23856 76 {}
N 23856 0 23902 0 {}
T {Xd5_x3N2} 23820 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 24038 0 0 0 {name=Xd5_x3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 24058 30 24058 76 {}
N 24018 0 23972 0 {}
N 24058 -30 24058 -76 {}
N 24058 0 24104 0 {}
T {Xd5_x3P0} 24022 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 24240 0 0 0 {name=Xd5_x3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 24260 30 24260 76 {}
N 24220 0 24174 0 {}
N 24260 -30 24260 -76 {}
N 24260 0 24306 0 {}
T {Xd5_x3P1} 24224 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 24442 0 0 0 {name=Xd5_x3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 24462 30 24462 76 {}
N 24422 0 24376 0 {}
N 24462 -30 24462 -76 {}
N 24462 0 24508 0 {}
T {Xd5_x3P2} 24426 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 24644 0 0 0 {name=Xd5_x4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 24664 -30 24664 -76 {}
N 24624 0 24578 0 {}
N 24664 30 24664 76 {}
N 24664 0 24710 0 {}
T {Xd5_x4N0} 24628 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 24846 0 0 0 {name=Xd5_x4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 24866 -30 24866 -76 {}
N 24826 0 24780 0 {}
N 24866 30 24866 76 {}
N 24866 0 24912 0 {}
T {Xd5_x4N1} 24830 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 25048 0 0 0 {name=Xd5_x4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 25068 -30 25068 -76 {}
N 25028 0 24982 0 {}
N 25068 30 25068 76 {}
N 25068 0 25114 0 {}
T {Xd5_x4N2} 25032 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 25250 0 0 0 {name=Xd5_x4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 25270 30 25270 76 {}
N 25230 0 25184 0 {}
N 25270 -30 25270 -76 {}
N 25270 0 25316 0 {}
T {Xd5_x4P0} 25234 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 25452 0 0 0 {name=Xd5_x4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 25472 30 25472 76 {}
N 25432 0 25386 0 {}
N 25472 -30 25472 -76 {}
N 25472 0 25518 0 {}
T {Xd5_x4P1} 25436 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 25654 0 0 0 {name=Xd5_x4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 25674 30 25674 76 {}
N 25634 0 25588 0 {}
N 25674 -30 25674 -76 {}
N 25674 0 25720 0 {}
T {Xd5_x4P2} 25638 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 25856 0 0 0 {name=Xd5_d0_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 25876 -30 25876 -76 {}
N 25836 0 25790 0 {}
N 25876 30 25876 76 {}
N 25876 0 25922 0 {}
T {Xd5_d0_g1N0} 25840 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 26058 0 0 0 {name=Xd5_d0_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 26078 -30 26078 -76 {}
N 26038 0 25992 0 {}
N 26078 30 26078 76 {}
N 26078 0 26124 0 {}
T {Xd5_d0_g1N1} 26042 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 26260 0 0 0 {name=Xd5_d0_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 26280 -30 26280 -76 {}
N 26240 0 26194 0 {}
N 26280 30 26280 76 {}
N 26280 0 26326 0 {}
T {Xd5_d0_g1N2} 26244 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 26462 0 0 0 {name=Xd5_d0_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 26482 30 26482 76 {}
N 26442 0 26396 0 {}
N 26482 -30 26482 -76 {}
N 26482 0 26528 0 {}
T {Xd5_d0_g1P0} 26446 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 26664 0 0 0 {name=Xd5_d0_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 26684 30 26684 76 {}
N 26644 0 26598 0 {}
N 26684 -30 26684 -76 {}
N 26684 0 26730 0 {}
T {Xd5_d0_g1P1} 26648 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 26866 0 0 0 {name=Xd5_d0_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 26886 30 26886 76 {}
N 26846 0 26800 0 {}
N 26886 -30 26886 -76 {}
N 26886 0 26932 0 {}
T {Xd5_d0_g1P2} 26850 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 27068 0 0 0 {name=Xd5_d0_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 27088 -30 27088 -76 {}
N 27048 0 27002 0 {}
N 27088 30 27088 76 {}
N 27088 0 27134 0 {}
T {Xd5_d0_g2N0} 27052 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 27270 0 0 0 {name=Xd5_d0_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 27290 -30 27290 -76 {}
N 27250 0 27204 0 {}
N 27290 30 27290 76 {}
N 27290 0 27336 0 {}
T {Xd5_d0_g2N1} 27254 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 27472 0 0 0 {name=Xd5_d0_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 27492 -30 27492 -76 {}
N 27452 0 27406 0 {}
N 27492 30 27492 76 {}
N 27492 0 27538 0 {}
T {Xd5_d0_g2N2} 27456 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 27674 0 0 0 {name=Xd5_d0_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 27694 30 27694 76 {}
N 27654 0 27608 0 {}
N 27694 -30 27694 -76 {}
N 27694 0 27740 0 {}
T {Xd5_d0_g2P0} 27658 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 27876 0 0 0 {name=Xd5_d0_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 27896 30 27896 76 {}
N 27856 0 27810 0 {}
N 27896 -30 27896 -76 {}
N 27896 0 27942 0 {}
T {Xd5_d0_g2P1} 27860 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 28078 0 0 0 {name=Xd5_d0_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 28098 30 28098 76 {}
N 28058 0 28012 0 {}
N 28098 -30 28098 -76 {}
N 28098 0 28144 0 {}
T {Xd5_d0_g2P2} 28062 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 28280 0 0 0 {name=Xd5_d0_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 28300 -30 28300 -76 {}
N 28260 0 28214 0 {}
N 28300 30 28300 76 {}
N 28300 0 28346 0 {}
T {Xd5_d0_g3N0} 28264 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 28482 0 0 0 {name=Xd5_d0_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 28502 -30 28502 -76 {}
N 28462 0 28416 0 {}
N 28502 30 28502 76 {}
N 28502 0 28548 0 {}
T {Xd5_d0_g3N1} 28466 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 28684 0 0 0 {name=Xd5_d0_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 28704 -30 28704 -76 {}
N 28664 0 28618 0 {}
N 28704 30 28704 76 {}
N 28704 0 28750 0 {}
T {Xd5_d0_g3N2} 28668 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 28886 0 0 0 {name=Xd5_d0_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 28906 30 28906 76 {}
N 28866 0 28820 0 {}
N 28906 -30 28906 -76 {}
N 28906 0 28952 0 {}
T {Xd5_d0_g3P0} 28870 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 29088 0 0 0 {name=Xd5_d0_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 29108 30 29108 76 {}
N 29068 0 29022 0 {}
N 29108 -30 29108 -76 {}
N 29108 0 29154 0 {}
T {Xd5_d0_g3P1} 29072 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 29290 0 0 0 {name=Xd5_d0_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 29310 30 29310 76 {}
N 29270 0 29224 0 {}
N 29310 -30 29310 -76 {}
N 29310 0 29356 0 {}
T {Xd5_d0_g3P2} 29274 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 29492 0 0 0 {name=Xd5_d0_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 29512 -30 29512 -76 {}
N 29472 0 29426 0 {}
N 29512 30 29512 76 {}
N 29512 0 29558 0 {}
T {Xd5_d0_g4N0} 29476 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 29694 0 0 0 {name=Xd5_d0_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 29714 -30 29714 -76 {}
N 29674 0 29628 0 {}
N 29714 30 29714 76 {}
N 29714 0 29760 0 {}
T {Xd5_d0_g4N1} 29678 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 29896 0 0 0 {name=Xd5_d0_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 29916 -30 29916 -76 {}
N 29876 0 29830 0 {}
N 29916 30 29916 76 {}
N 29916 0 29962 0 {}
T {Xd5_d0_g4N2} 29880 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 30098 0 0 0 {name=Xd5_d0_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 30118 30 30118 76 {}
N 30078 0 30032 0 {}
N 30118 -30 30118 -76 {}
N 30118 0 30164 0 {}
T {Xd5_d0_g4P0} 30082 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 30300 0 0 0 {name=Xd5_d0_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 30320 30 30320 76 {}
N 30280 0 30234 0 {}
N 30320 -30 30320 -76 {}
N 30320 0 30366 0 {}
T {Xd5_d0_g4P1} 30284 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 30502 0 0 0 {name=Xd5_d0_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 30522 30 30522 76 {}
N 30482 0 30436 0 {}
N 30522 -30 30522 -76 {}
N 30522 0 30568 0 {}
T {Xd5_d0_g4P2} 30486 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 30704 0 0 0 {name=Xd5_d0_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 30724 -30 30724 -76 {}
N 30684 0 30638 0 {}
N 30724 30 30724 76 {}
N 30724 0 30770 0 {}
T {Xd5_d0_g5N0} 30688 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 30906 0 0 0 {name=Xd5_d0_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 30926 -30 30926 -76 {}
N 30886 0 30840 0 {}
N 30926 30 30926 76 {}
N 30926 0 30972 0 {}
T {Xd5_d0_g5N1} 30890 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 31108 0 0 0 {name=Xd5_d0_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 31128 -30 31128 -76 {}
N 31088 0 31042 0 {}
N 31128 30 31128 76 {}
N 31128 0 31174 0 {}
T {Xd5_d0_g5N2} 31092 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 31310 0 0 0 {name=Xd5_d0_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 31330 30 31330 76 {}
N 31290 0 31244 0 {}
N 31330 -30 31330 -76 {}
N 31330 0 31376 0 {}
T {Xd5_d0_g5P0} 31294 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 31512 0 0 0 {name=Xd5_d0_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 31532 30 31532 76 {}
N 31492 0 31446 0 {}
N 31532 -30 31532 -76 {}
N 31532 0 31578 0 {}
T {Xd5_d0_g5P1} 31496 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 31714 0 0 0 {name=Xd5_d0_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 31734 30 31734 76 {}
N 31694 0 31648 0 {}
N 31734 -30 31734 -76 {}
N 31734 0 31780 0 {}
T {Xd5_d0_g5P2} 31698 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 31916 0 0 0 {name=Xd5_d0_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 31936 -30 31936 -76 {}
N 31896 0 31850 0 {}
N 31936 30 31936 76 {}
N 31936 0 31982 0 {}
T {Xd5_d0_g6N0} 31900 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 32118 0 0 0 {name=Xd5_d0_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 32138 -30 32138 -76 {}
N 32098 0 32052 0 {}
N 32138 30 32138 76 {}
N 32138 0 32184 0 {}
T {Xd5_d0_g6N1} 32102 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 32320 0 0 0 {name=Xd5_d0_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 32340 -30 32340 -76 {}
N 32300 0 32254 0 {}
N 32340 30 32340 76 {}
N 32340 0 32386 0 {}
T {Xd5_d0_g6N2} 32304 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 32522 0 0 0 {name=Xd5_d0_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 32542 30 32542 76 {}
N 32502 0 32456 0 {}
N 32542 -30 32542 -76 {}
N 32542 0 32588 0 {}
T {Xd5_d0_g6P0} 32506 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 32724 0 0 0 {name=Xd5_d0_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 32744 30 32744 76 {}
N 32704 0 32658 0 {}
N 32744 -30 32744 -76 {}
N 32744 0 32790 0 {}
T {Xd5_d0_g6P1} 32708 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 32926 0 0 0 {name=Xd5_d0_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 32946 30 32946 76 {}
N 32906 0 32860 0 {}
N 32946 -30 32946 -76 {}
N 32946 0 32992 0 {}
T {Xd5_d0_g6P2} 32910 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 33128 0 0 0 {name=Xd5_d1_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 33148 -30 33148 -76 {}
N 33108 0 33062 0 {}
N 33148 30 33148 76 {}
N 33148 0 33194 0 {}
T {Xd5_d1_g1N0} 33112 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 33330 0 0 0 {name=Xd5_d1_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 33350 -30 33350 -76 {}
N 33310 0 33264 0 {}
N 33350 30 33350 76 {}
N 33350 0 33396 0 {}
T {Xd5_d1_g1N1} 33314 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 33532 0 0 0 {name=Xd5_d1_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 33552 -30 33552 -76 {}
N 33512 0 33466 0 {}
N 33552 30 33552 76 {}
N 33552 0 33598 0 {}
T {Xd5_d1_g1N2} 33516 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 33734 0 0 0 {name=Xd5_d1_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 33754 30 33754 76 {}
N 33714 0 33668 0 {}
N 33754 -30 33754 -76 {}
N 33754 0 33800 0 {}
T {Xd5_d1_g1P0} 33718 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 33936 0 0 0 {name=Xd5_d1_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 33956 30 33956 76 {}
N 33916 0 33870 0 {}
N 33956 -30 33956 -76 {}
N 33956 0 34002 0 {}
T {Xd5_d1_g1P1} 33920 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 34138 0 0 0 {name=Xd5_d1_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 34158 30 34158 76 {}
N 34118 0 34072 0 {}
N 34158 -30 34158 -76 {}
N 34158 0 34204 0 {}
T {Xd5_d1_g1P2} 34122 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 34340 0 0 0 {name=Xd5_d1_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 34360 -30 34360 -76 {}
N 34320 0 34274 0 {}
N 34360 30 34360 76 {}
N 34360 0 34406 0 {}
T {Xd5_d1_g2N0} 34324 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 34542 0 0 0 {name=Xd5_d1_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 34562 -30 34562 -76 {}
N 34522 0 34476 0 {}
N 34562 30 34562 76 {}
N 34562 0 34608 0 {}
T {Xd5_d1_g2N1} 34526 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 34744 0 0 0 {name=Xd5_d1_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 34764 -30 34764 -76 {}
N 34724 0 34678 0 {}
N 34764 30 34764 76 {}
N 34764 0 34810 0 {}
T {Xd5_d1_g2N2} 34728 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 34946 0 0 0 {name=Xd5_d1_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 34966 30 34966 76 {}
N 34926 0 34880 0 {}
N 34966 -30 34966 -76 {}
N 34966 0 35012 0 {}
T {Xd5_d1_g2P0} 34930 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 35148 0 0 0 {name=Xd5_d1_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 35168 30 35168 76 {}
N 35128 0 35082 0 {}
N 35168 -30 35168 -76 {}
N 35168 0 35214 0 {}
T {Xd5_d1_g2P1} 35132 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 35350 0 0 0 {name=Xd5_d1_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 35370 30 35370 76 {}
N 35330 0 35284 0 {}
N 35370 -30 35370 -76 {}
N 35370 0 35416 0 {}
T {Xd5_d1_g2P2} 35334 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 35552 0 0 0 {name=Xd5_d1_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 35572 -30 35572 -76 {}
N 35532 0 35486 0 {}
N 35572 30 35572 76 {}
N 35572 0 35618 0 {}
T {Xd5_d1_g3N0} 35536 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 35754 0 0 0 {name=Xd5_d1_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 35774 -30 35774 -76 {}
N 35734 0 35688 0 {}
N 35774 30 35774 76 {}
N 35774 0 35820 0 {}
T {Xd5_d1_g3N1} 35738 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 35956 0 0 0 {name=Xd5_d1_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 35976 -30 35976 -76 {}
N 35936 0 35890 0 {}
N 35976 30 35976 76 {}
N 35976 0 36022 0 {}
T {Xd5_d1_g3N2} 35940 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 36158 0 0 0 {name=Xd5_d1_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 36178 30 36178 76 {}
N 36138 0 36092 0 {}
N 36178 -30 36178 -76 {}
N 36178 0 36224 0 {}
T {Xd5_d1_g3P0} 36142 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 36360 0 0 0 {name=Xd5_d1_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 36380 30 36380 76 {}
N 36340 0 36294 0 {}
N 36380 -30 36380 -76 {}
N 36380 0 36426 0 {}
T {Xd5_d1_g3P1} 36344 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 36562 0 0 0 {name=Xd5_d1_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 36582 30 36582 76 {}
N 36542 0 36496 0 {}
N 36582 -30 36582 -76 {}
N 36582 0 36628 0 {}
T {Xd5_d1_g3P2} 36546 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 36764 0 0 0 {name=Xd5_d1_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 36784 -30 36784 -76 {}
N 36744 0 36698 0 {}
N 36784 30 36784 76 {}
N 36784 0 36830 0 {}
T {Xd5_d1_g4N0} 36748 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 36966 0 0 0 {name=Xd5_d1_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 36986 -30 36986 -76 {}
N 36946 0 36900 0 {}
N 36986 30 36986 76 {}
N 36986 0 37032 0 {}
T {Xd5_d1_g4N1} 36950 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 37168 0 0 0 {name=Xd5_d1_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 37188 -30 37188 -76 {}
N 37148 0 37102 0 {}
N 37188 30 37188 76 {}
N 37188 0 37234 0 {}
T {Xd5_d1_g4N2} 37152 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 37370 0 0 0 {name=Xd5_d1_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 37390 30 37390 76 {}
N 37350 0 37304 0 {}
N 37390 -30 37390 -76 {}
N 37390 0 37436 0 {}
T {Xd5_d1_g4P0} 37354 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 37572 0 0 0 {name=Xd5_d1_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 37592 30 37592 76 {}
N 37552 0 37506 0 {}
N 37592 -30 37592 -76 {}
N 37592 0 37638 0 {}
T {Xd5_d1_g4P1} 37556 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 37774 0 0 0 {name=Xd5_d1_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 37794 30 37794 76 {}
N 37754 0 37708 0 {}
N 37794 -30 37794 -76 {}
N 37794 0 37840 0 {}
T {Xd5_d1_g4P2} 37758 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 37976 0 0 0 {name=Xd5_d1_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 37996 -30 37996 -76 {}
N 37956 0 37910 0 {}
N 37996 30 37996 76 {}
N 37996 0 38042 0 {}
T {Xd5_d1_g5N0} 37960 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 38178 0 0 0 {name=Xd5_d1_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 38198 -30 38198 -76 {}
N 38158 0 38112 0 {}
N 38198 30 38198 76 {}
N 38198 0 38244 0 {}
T {Xd5_d1_g5N1} 38162 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 38380 0 0 0 {name=Xd5_d1_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 38400 -30 38400 -76 {}
N 38360 0 38314 0 {}
N 38400 30 38400 76 {}
N 38400 0 38446 0 {}
T {Xd5_d1_g5N2} 38364 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 38582 0 0 0 {name=Xd5_d1_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 38602 30 38602 76 {}
N 38562 0 38516 0 {}
N 38602 -30 38602 -76 {}
N 38602 0 38648 0 {}
T {Xd5_d1_g5P0} 38566 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 38784 0 0 0 {name=Xd5_d1_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 38804 30 38804 76 {}
N 38764 0 38718 0 {}
N 38804 -30 38804 -76 {}
N 38804 0 38850 0 {}
T {Xd5_d1_g5P1} 38768 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 38986 0 0 0 {name=Xd5_d1_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 39006 30 39006 76 {}
N 38966 0 38920 0 {}
N 39006 -30 39006 -76 {}
N 39006 0 39052 0 {}
T {Xd5_d1_g5P2} 38970 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 39188 0 0 0 {name=Xd5_d1_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 39208 -30 39208 -76 {}
N 39168 0 39122 0 {}
N 39208 30 39208 76 {}
N 39208 0 39254 0 {}
T {Xd5_d1_g6N0} 39172 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 39390 0 0 0 {name=Xd5_d1_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 39410 -30 39410 -76 {}
N 39370 0 39324 0 {}
N 39410 30 39410 76 {}
N 39410 0 39456 0 {}
T {Xd5_d1_g6N1} 39374 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 39592 0 0 0 {name=Xd5_d1_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 39612 -30 39612 -76 {}
N 39572 0 39526 0 {}
N 39612 30 39612 76 {}
N 39612 0 39658 0 {}
T {Xd5_d1_g6N2} 39576 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 39794 0 0 0 {name=Xd5_d1_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 39814 30 39814 76 {}
N 39774 0 39728 0 {}
N 39814 -30 39814 -76 {}
N 39814 0 39860 0 {}
T {Xd5_d1_g6P0} 39778 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 39996 0 0 0 {name=Xd5_d1_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 40016 30 40016 76 {}
N 39976 0 39930 0 {}
N 40016 -30 40016 -76 {}
N 40016 0 40062 0 {}
T {Xd5_d1_g6P1} 39980 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 40198 0 0 0 {name=Xd5_d1_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 40218 30 40218 76 {}
N 40178 0 40132 0 {}
N 40218 -30 40218 -76 {}
N 40218 0 40264 0 {}
T {Xd5_d1_g6P2} 40182 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 40400 0 0 0 {name=Xd5_d2_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 40420 -30 40420 -76 {}
N 40380 0 40334 0 {}
N 40420 30 40420 76 {}
N 40420 0 40466 0 {}
T {Xd5_d2_g1N0} 40384 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 40602 0 0 0 {name=Xd5_d2_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 40622 -30 40622 -76 {}
N 40582 0 40536 0 {}
N 40622 30 40622 76 {}
N 40622 0 40668 0 {}
T {Xd5_d2_g1N1} 40586 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 40804 0 0 0 {name=Xd5_d2_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 40824 -30 40824 -76 {}
N 40784 0 40738 0 {}
N 40824 30 40824 76 {}
N 40824 0 40870 0 {}
T {Xd5_d2_g1N2} 40788 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 41006 0 0 0 {name=Xd5_d2_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 41026 30 41026 76 {}
N 40986 0 40940 0 {}
N 41026 -30 41026 -76 {}
N 41026 0 41072 0 {}
T {Xd5_d2_g1P0} 40990 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 41208 0 0 0 {name=Xd5_d2_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 41228 30 41228 76 {}
N 41188 0 41142 0 {}
N 41228 -30 41228 -76 {}
N 41228 0 41274 0 {}
T {Xd5_d2_g1P1} 41192 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 41410 0 0 0 {name=Xd5_d2_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 41430 30 41430 76 {}
N 41390 0 41344 0 {}
N 41430 -30 41430 -76 {}
N 41430 0 41476 0 {}
T {Xd5_d2_g1P2} 41394 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 41612 0 0 0 {name=Xd5_d2_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 41632 -30 41632 -76 {}
N 41592 0 41546 0 {}
N 41632 30 41632 76 {}
N 41632 0 41678 0 {}
T {Xd5_d2_g2N0} 41596 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 41814 0 0 0 {name=Xd5_d2_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 41834 -30 41834 -76 {}
N 41794 0 41748 0 {}
N 41834 30 41834 76 {}
N 41834 0 41880 0 {}
T {Xd5_d2_g2N1} 41798 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 42016 0 0 0 {name=Xd5_d2_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 42036 -30 42036 -76 {}
N 41996 0 41950 0 {}
N 42036 30 42036 76 {}
N 42036 0 42082 0 {}
T {Xd5_d2_g2N2} 42000 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 42218 0 0 0 {name=Xd5_d2_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 42238 30 42238 76 {}
N 42198 0 42152 0 {}
N 42238 -30 42238 -76 {}
N 42238 0 42284 0 {}
T {Xd5_d2_g2P0} 42202 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 42420 0 0 0 {name=Xd5_d2_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 42440 30 42440 76 {}
N 42400 0 42354 0 {}
N 42440 -30 42440 -76 {}
N 42440 0 42486 0 {}
T {Xd5_d2_g2P1} 42404 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 42622 0 0 0 {name=Xd5_d2_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 42642 30 42642 76 {}
N 42602 0 42556 0 {}
N 42642 -30 42642 -76 {}
N 42642 0 42688 0 {}
T {Xd5_d2_g2P2} 42606 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 42824 0 0 0 {name=Xd5_d2_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 42844 -30 42844 -76 {}
N 42804 0 42758 0 {}
N 42844 30 42844 76 {}
N 42844 0 42890 0 {}
T {Xd5_d2_g3N0} 42808 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 43026 0 0 0 {name=Xd5_d2_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 43046 -30 43046 -76 {}
N 43006 0 42960 0 {}
N 43046 30 43046 76 {}
N 43046 0 43092 0 {}
T {Xd5_d2_g3N1} 43010 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 43228 0 0 0 {name=Xd5_d2_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 43248 -30 43248 -76 {}
N 43208 0 43162 0 {}
N 43248 30 43248 76 {}
N 43248 0 43294 0 {}
T {Xd5_d2_g3N2} 43212 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 43430 0 0 0 {name=Xd5_d2_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 43450 30 43450 76 {}
N 43410 0 43364 0 {}
N 43450 -30 43450 -76 {}
N 43450 0 43496 0 {}
T {Xd5_d2_g3P0} 43414 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 43632 0 0 0 {name=Xd5_d2_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 43652 30 43652 76 {}
N 43612 0 43566 0 {}
N 43652 -30 43652 -76 {}
N 43652 0 43698 0 {}
T {Xd5_d2_g3P1} 43616 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 43834 0 0 0 {name=Xd5_d2_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 43854 30 43854 76 {}
N 43814 0 43768 0 {}
N 43854 -30 43854 -76 {}
N 43854 0 43900 0 {}
T {Xd5_d2_g3P2} 43818 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 44036 0 0 0 {name=Xd5_d2_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 44056 -30 44056 -76 {}
N 44016 0 43970 0 {}
N 44056 30 44056 76 {}
N 44056 0 44102 0 {}
T {Xd5_d2_g4N0} 44020 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 44238 0 0 0 {name=Xd5_d2_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 44258 -30 44258 -76 {}
N 44218 0 44172 0 {}
N 44258 30 44258 76 {}
N 44258 0 44304 0 {}
T {Xd5_d2_g4N1} 44222 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 44440 0 0 0 {name=Xd5_d2_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 44460 -30 44460 -76 {}
N 44420 0 44374 0 {}
N 44460 30 44460 76 {}
N 44460 0 44506 0 {}
T {Xd5_d2_g4N2} 44424 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 44642 0 0 0 {name=Xd5_d2_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 44662 30 44662 76 {}
N 44622 0 44576 0 {}
N 44662 -30 44662 -76 {}
N 44662 0 44708 0 {}
T {Xd5_d2_g4P0} 44626 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 44844 0 0 0 {name=Xd5_d2_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 44864 30 44864 76 {}
N 44824 0 44778 0 {}
N 44864 -30 44864 -76 {}
N 44864 0 44910 0 {}
T {Xd5_d2_g4P1} 44828 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 45046 0 0 0 {name=Xd5_d2_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 45066 30 45066 76 {}
N 45026 0 44980 0 {}
N 45066 -30 45066 -76 {}
N 45066 0 45112 0 {}
T {Xd5_d2_g4P2} 45030 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 45248 0 0 0 {name=Xd5_d2_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 45268 -30 45268 -76 {}
N 45228 0 45182 0 {}
N 45268 30 45268 76 {}
N 45268 0 45314 0 {}
T {Xd5_d2_g5N0} 45232 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 45450 0 0 0 {name=Xd5_d2_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 45470 -30 45470 -76 {}
N 45430 0 45384 0 {}
N 45470 30 45470 76 {}
N 45470 0 45516 0 {}
T {Xd5_d2_g5N1} 45434 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 45652 0 0 0 {name=Xd5_d2_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 45672 -30 45672 -76 {}
N 45632 0 45586 0 {}
N 45672 30 45672 76 {}
N 45672 0 45718 0 {}
T {Xd5_d2_g5N2} 45636 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 45854 0 0 0 {name=Xd5_d2_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 45874 30 45874 76 {}
N 45834 0 45788 0 {}
N 45874 -30 45874 -76 {}
N 45874 0 45920 0 {}
T {Xd5_d2_g5P0} 45838 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 46056 0 0 0 {name=Xd5_d2_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 46076 30 46076 76 {}
N 46036 0 45990 0 {}
N 46076 -30 46076 -76 {}
N 46076 0 46122 0 {}
T {Xd5_d2_g5P1} 46040 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 46258 0 0 0 {name=Xd5_d2_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 46278 30 46278 76 {}
N 46238 0 46192 0 {}
N 46278 -30 46278 -76 {}
N 46278 0 46324 0 {}
T {Xd5_d2_g5P2} 46242 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 46460 0 0 0 {name=Xd5_d2_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 46480 -30 46480 -76 {}
N 46440 0 46394 0 {}
N 46480 30 46480 76 {}
N 46480 0 46526 0 {}
T {Xd5_d2_g6N0} 46444 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 46662 0 0 0 {name=Xd5_d2_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 46682 -30 46682 -76 {}
N 46642 0 46596 0 {}
N 46682 30 46682 76 {}
N 46682 0 46728 0 {}
T {Xd5_d2_g6N1} 46646 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 46864 0 0 0 {name=Xd5_d2_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 46884 -30 46884 -76 {}
N 46844 0 46798 0 {}
N 46884 30 46884 76 {}
N 46884 0 46930 0 {}
T {Xd5_d2_g6N2} 46848 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 47066 0 0 0 {name=Xd5_d2_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 47086 30 47086 76 {}
N 47046 0 47000 0 {}
N 47086 -30 47086 -76 {}
N 47086 0 47132 0 {}
T {Xd5_d2_g6P0} 47050 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 47268 0 0 0 {name=Xd5_d2_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 47288 30 47288 76 {}
N 47248 0 47202 0 {}
N 47288 -30 47288 -76 {}
N 47288 0 47334 0 {}
T {Xd5_d2_g6P1} 47252 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 47470 0 0 0 {name=Xd5_d2_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 47490 30 47490 76 {}
N 47450 0 47404 0 {}
N 47490 -30 47490 -76 {}
N 47490 0 47536 0 {}
T {Xd5_d2_g6P2} 47454 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 47672 0 0 0 {name=Xd2_inv1N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 47692 -30 47692 -76 {}
N 47652 0 47606 0 {}
N 47692 30 47692 76 {}
N 47692 0 47738 0 {}
T {Xd2_inv1N} 47656 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 47874 0 0 0 {name=Xd2_inv1P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 47894 30 47894 76 {}
N 47854 0 47808 0 {}
N 47894 -30 47894 -76 {}
N 47894 0 47940 0 {}
T {Xd2_inv1P} 47858 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 48076 0 0 0 {name=Xd2_inv2N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 48096 -30 48096 -76 {}
N 48056 0 48010 0 {}
N 48096 30 48096 76 {}
N 48096 0 48142 0 {}
T {Xd2_inv2N} 48060 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 48278 0 0 0 {name=Xd2_inv2P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 48298 30 48298 76 {}
N 48258 0 48212 0 {}
N 48298 -30 48298 -76 {}
N 48298 0 48344 0 {}
T {Xd2_inv2P} 48262 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 48480 0 0 0 {name=Xd2_inv3N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 48500 -30 48500 -76 {}
N 48460 0 48414 0 {}
N 48500 30 48500 76 {}
N 48500 0 48546 0 {}
T {Xd2_inv3N} 48464 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 48682 0 0 0 {name=Xd2_inv3P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 48702 30 48702 76 {}
N 48662 0 48616 0 {}
N 48702 -30 48702 -76 {}
N 48702 0 48748 0 {}
T {Xd2_inv3P} 48666 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 48884 0 0 0 {name=Xd2_inv4N
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 48904 -30 48904 -76 {}
N 48864 0 48818 0 {}
N 48904 30 48904 76 {}
N 48904 0 48950 0 {}
T {Xd2_inv4N} 48868 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 49086 0 0 0 {name=Xd2_inv4P
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 49106 30 49106 76 {}
N 49066 0 49020 0 {}
N 49106 -30 49106 -76 {}
N 49106 0 49152 0 {}
T {Xd2_inv4P} 49070 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 49288 0 0 0 {name=Xd2_dff_g1N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 49308 -30 49308 -76 {}
N 49268 0 49222 0 {}
N 49308 30 49308 76 {}
N 49308 0 49354 0 {}
T {Xd2_dff_g1N0} 49272 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 49490 0 0 0 {name=Xd2_dff_g1N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 49510 -30 49510 -76 {}
N 49470 0 49424 0 {}
N 49510 30 49510 76 {}
N 49510 0 49556 0 {}
T {Xd2_dff_g1N1} 49474 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 49692 0 0 0 {name=Xd2_dff_g1N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 49712 -30 49712 -76 {}
N 49672 0 49626 0 {}
N 49712 30 49712 76 {}
N 49712 0 49758 0 {}
T {Xd2_dff_g1N2} 49676 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 49894 0 0 0 {name=Xd2_dff_g1P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 49914 30 49914 76 {}
N 49874 0 49828 0 {}
N 49914 -30 49914 -76 {}
N 49914 0 49960 0 {}
T {Xd2_dff_g1P0} 49878 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 50096 0 0 0 {name=Xd2_dff_g1P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 50116 30 50116 76 {}
N 50076 0 50030 0 {}
N 50116 -30 50116 -76 {}
N 50116 0 50162 0 {}
T {Xd2_dff_g1P1} 50080 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 50298 0 0 0 {name=Xd2_dff_g1P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 50318 30 50318 76 {}
N 50278 0 50232 0 {}
N 50318 -30 50318 -76 {}
N 50318 0 50364 0 {}
T {Xd2_dff_g1P2} 50282 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 50500 0 0 0 {name=Xd2_dff_g2N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 50520 -30 50520 -76 {}
N 50480 0 50434 0 {}
N 50520 30 50520 76 {}
N 50520 0 50566 0 {}
T {Xd2_dff_g2N0} 50484 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 50702 0 0 0 {name=Xd2_dff_g2N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 50722 -30 50722 -76 {}
N 50682 0 50636 0 {}
N 50722 30 50722 76 {}
N 50722 0 50768 0 {}
T {Xd2_dff_g2N1} 50686 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 50904 0 0 0 {name=Xd2_dff_g2N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 50924 -30 50924 -76 {}
N 50884 0 50838 0 {}
N 50924 30 50924 76 {}
N 50924 0 50970 0 {}
T {Xd2_dff_g2N2} 50888 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 51106 0 0 0 {name=Xd2_dff_g2P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 51126 30 51126 76 {}
N 51086 0 51040 0 {}
N 51126 -30 51126 -76 {}
N 51126 0 51172 0 {}
T {Xd2_dff_g2P0} 51090 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 51308 0 0 0 {name=Xd2_dff_g2P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 51328 30 51328 76 {}
N 51288 0 51242 0 {}
N 51328 -30 51328 -76 {}
N 51328 0 51374 0 {}
T {Xd2_dff_g2P1} 51292 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 51510 0 0 0 {name=Xd2_dff_g2P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 51530 30 51530 76 {}
N 51490 0 51444 0 {}
N 51530 -30 51530 -76 {}
N 51530 0 51576 0 {}
T {Xd2_dff_g2P2} 51494 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 51712 0 0 0 {name=Xd2_dff_g3N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 51732 -30 51732 -76 {}
N 51692 0 51646 0 {}
N 51732 30 51732 76 {}
N 51732 0 51778 0 {}
T {Xd2_dff_g3N0} 51696 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 51914 0 0 0 {name=Xd2_dff_g3N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 51934 -30 51934 -76 {}
N 51894 0 51848 0 {}
N 51934 30 51934 76 {}
N 51934 0 51980 0 {}
T {Xd2_dff_g3N1} 51898 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 52116 0 0 0 {name=Xd2_dff_g3N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 52136 -30 52136 -76 {}
N 52096 0 52050 0 {}
N 52136 30 52136 76 {}
N 52136 0 52182 0 {}
T {Xd2_dff_g3N2} 52100 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 52318 0 0 0 {name=Xd2_dff_g3P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 52338 30 52338 76 {}
N 52298 0 52252 0 {}
N 52338 -30 52338 -76 {}
N 52338 0 52384 0 {}
T {Xd2_dff_g3P0} 52302 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 52520 0 0 0 {name=Xd2_dff_g3P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 52540 30 52540 76 {}
N 52500 0 52454 0 {}
N 52540 -30 52540 -76 {}
N 52540 0 52586 0 {}
T {Xd2_dff_g3P1} 52504 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 52722 0 0 0 {name=Xd2_dff_g3P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 52742 30 52742 76 {}
N 52702 0 52656 0 {}
N 52742 -30 52742 -76 {}
N 52742 0 52788 0 {}
T {Xd2_dff_g3P2} 52706 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 52924 0 0 0 {name=Xd2_dff_g4N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 52944 -30 52944 -76 {}
N 52904 0 52858 0 {}
N 52944 30 52944 76 {}
N 52944 0 52990 0 {}
T {Xd2_dff_g4N0} 52908 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 53126 0 0 0 {name=Xd2_dff_g4N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 53146 -30 53146 -76 {}
N 53106 0 53060 0 {}
N 53146 30 53146 76 {}
N 53146 0 53192 0 {}
T {Xd2_dff_g4N1} 53110 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 53328 0 0 0 {name=Xd2_dff_g4N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 53348 -30 53348 -76 {}
N 53308 0 53262 0 {}
N 53348 30 53348 76 {}
N 53348 0 53394 0 {}
T {Xd2_dff_g4N2} 53312 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 53530 0 0 0 {name=Xd2_dff_g4P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 53550 30 53550 76 {}
N 53510 0 53464 0 {}
N 53550 -30 53550 -76 {}
N 53550 0 53596 0 {}
T {Xd2_dff_g4P0} 53514 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 53732 0 0 0 {name=Xd2_dff_g4P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 53752 30 53752 76 {}
N 53712 0 53666 0 {}
N 53752 -30 53752 -76 {}
N 53752 0 53798 0 {}
T {Xd2_dff_g4P1} 53716 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 53934 0 0 0 {name=Xd2_dff_g4P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 53954 30 53954 76 {}
N 53914 0 53868 0 {}
N 53954 -30 53954 -76 {}
N 53954 0 54000 0 {}
T {Xd2_dff_g4P2} 53918 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 54136 0 0 0 {name=Xd2_dff_g5N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 54156 -30 54156 -76 {}
N 54116 0 54070 0 {}
N 54156 30 54156 76 {}
N 54156 0 54202 0 {}
T {Xd2_dff_g5N0} 54120 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 54338 0 0 0 {name=Xd2_dff_g5N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 54358 -30 54358 -76 {}
N 54318 0 54272 0 {}
N 54358 30 54358 76 {}
N 54358 0 54404 0 {}
T {Xd2_dff_g5N1} 54322 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 54540 0 0 0 {name=Xd2_dff_g5N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 54560 -30 54560 -76 {}
N 54520 0 54474 0 {}
N 54560 30 54560 76 {}
N 54560 0 54606 0 {}
T {Xd2_dff_g5N2} 54524 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 54742 0 0 0 {name=Xd2_dff_g5P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 54762 30 54762 76 {}
N 54722 0 54676 0 {}
N 54762 -30 54762 -76 {}
N 54762 0 54808 0 {}
T {Xd2_dff_g5P0} 54726 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 54944 0 0 0 {name=Xd2_dff_g5P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 54964 30 54964 76 {}
N 54924 0 54878 0 {}
N 54964 -30 54964 -76 {}
N 54964 0 55010 0 {}
T {Xd2_dff_g5P1} 54928 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 55146 0 0 0 {name=Xd2_dff_g5P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 55166 30 55166 76 {}
N 55126 0 55080 0 {}
N 55166 -30 55166 -76 {}
N 55166 0 55212 0 {}
T {Xd2_dff_g5P2} 55130 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 55348 0 0 0 {name=Xd2_dff_g6N0
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 55368 -30 55368 -76 {}
N 55328 0 55282 0 {}
N 55368 30 55368 76 {}
N 55368 0 55414 0 {}
T {Xd2_dff_g6N0} 55332 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 55550 0 0 0 {name=Xd2_dff_g6N1
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 55570 -30 55570 -76 {}
N 55530 0 55484 0 {}
N 55570 30 55570 76 {}
N 55570 0 55616 0 {}
T {Xd2_dff_g6N1} 55534 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/nfet_01v8.sym} 55752 0 0 0 {name=Xd2_dff_g6N2
L=0.15
W=0.65
nf=1
model=nfet_01v8
spiceprefix=X}
N 55772 -30 55772 -76 {}
N 55732 0 55686 0 {}
N 55772 30 55772 76 {}
N 55772 0 55818 0 {}
T {Xd2_dff_g6N2} 55736 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 55954 0 0 0 {name=Xd2_dff_g6P0
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 55974 30 55974 76 {}
N 55934 0 55888 0 {}
N 55974 -30 55974 -76 {}
N 55974 0 56020 0 {}
T {Xd2_dff_g6P0} 55938 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 56156 0 0 0 {name=Xd2_dff_g6P1
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 56176 30 56176 76 {}
N 56136 0 56090 0 {}
N 56176 -30 56176 -76 {}
N 56176 0 56222 0 {}
T {Xd2_dff_g6P1} 56140 76 0 0 0.11 0.11 {layer=13}
C {sky130_fd_pr/pfet_01v8.sym} 56358 0 0 0 {name=Xd2_dff_g6P2
L=0.15
W=1.0
nf=1
model=pfet_01v8
spiceprefix=X}
N 56378 30 56378 76 {}
N 56338 0 56292 0 {}
N 56378 -30 56378 -76 {}
N 56378 0 56424 0 {}
T {Xd2_dff_g6P2} 56342 76 0 0 0.11 0.11 {layer=13}
N 20 -76 20 -116 {}
N 338 0 338 -116 {}
N 540 0 540 -116 {}
N -66 0 -66 116 {}
N 136 0 136 116 {}
N 6802 0 6802 116 {}
N 7408 0 7408 116 {}
N 8302 76 8302 116 {}
N 8504 76 8504 116 {}
N 8706 76 8706 116 {}
N 20 76 20 2844 {}
N 66 0 66 2844 {}
N 424 76 424 2844 {}
N 470 0 470 2844 {}
N 828 76 828 2844 {}
N 874 0 874 2844 {}
N 1232 76 1232 2844 {}
N 1278 0 1278 2844 {}
N 1636 76 1636 2844 {}
N 1682 0 1682 2844 {}
N 1884 0 1884 2844 {}
N 2086 0 2086 2844 {}
N 2848 76 2848 2844 {}
N 2894 0 2894 2844 {}
N 3096 0 3096 2844 {}
N 3298 0 3298 2844 {}
N 4060 76 4060 2844 {}
N 4106 0 4106 2844 {}
N 4308 0 4308 2844 {}
N 4510 0 4510 2844 {}
N 5272 76 5272 2844 {}
N 5318 0 5318 2844 {}
N 5520 0 5520 2844 {}
N 5722 0 5722 2844 {}
N 6484 76 6484 2844 {}
N 6530 0 6530 2844 {}
N 6732 0 6732 2844 {}
N 6934 0 6934 2844 {}
N 7696 76 7696 2844 {}
N 7742 0 7742 2844 {}
N 7944 0 7944 2844 {}
N 8146 0 8146 2844 {}
N 8908 76 8908 2844 {}
N 8954 0 8954 2844 {}
N 9312 76 9312 2844 {}
N 9358 0 9358 2844 {}
N 9716 76 9716 2844 {}
N 9762 0 9762 2844 {}
N 10120 76 10120 2844 {}
N 10166 0 10166 2844 {}
N 10524 76 10524 2844 {}
N 10570 0 10570 2844 {}
N 10772 0 10772 2844 {}
N 10974 0 10974 2844 {}
N 11736 76 11736 2844 {}
N 11782 0 11782 2844 {}
N 11984 0 11984 2844 {}
N 12186 0 12186 2844 {}
N 12948 76 12948 2844 {}
N 12994 0 12994 2844 {}
N 13196 0 13196 2844 {}
N 13398 0 13398 2844 {}
N 14160 76 14160 2844 {}
N 14206 0 14206 2844 {}
N 14408 0 14408 2844 {}
N 14610 0 14610 2844 {}
N 15372 76 15372 2844 {}
N 15418 0 15418 2844 {}
N 15620 0 15620 2844 {}
N 15822 0 15822 2844 {}
N 16584 76 16584 2844 {}
N 16630 0 16630 2844 {}
N 16832 0 16832 2844 {}
N 17034 0 17034 2844 {}
N 17796 76 17796 2844 {}
N 17842 0 17842 2844 {}
N 18044 0 18044 2844 {}
N 18246 0 18246 2844 {}
N 19008 76 19008 2844 {}
N 19054 0 19054 2844 {}
N 19412 76 19412 2844 {}
N 19458 0 19458 2844 {}
N 19660 0 19660 2844 {}
N 19862 0 19862 2844 {}
N 20624 76 20624 2844 {}
N 20670 0 20670 2844 {}
N 21028 76 21028 2844 {}
N 21074 0 21074 2844 {}
N 21276 0 21276 2844 {}
N 21478 0 21478 2844 {}
N 22240 76 22240 2844 {}
N 22286 0 22286 2844 {}
N 22488 0 22488 2844 {}
N 22690 0 22690 2844 {}
N 23452 76 23452 2844 {}
N 23498 0 23498 2844 {}
N 23700 0 23700 2844 {}
N 23902 0 23902 2844 {}
N 24664 76 24664 2844 {}
N 24710 0 24710 2844 {}
N 24912 0 24912 2844 {}
N 25114 0 25114 2844 {}
N 25876 76 25876 2844 {}
N 25922 0 25922 2844 {}
N 26124 0 26124 2844 {}
N 26326 0 26326 2844 {}
N 27088 76 27088 2844 {}
N 27134 0 27134 2844 {}
N 27336 0 27336 2844 {}
N 27538 0 27538 2844 {}
N 28300 76 28300 2844 {}
N 28346 0 28346 2844 {}
N 28548 0 28548 2844 {}
N 28750 0 28750 2844 {}
N 29512 76 29512 2844 {}
N 29558 0 29558 2844 {}
N 29760 0 29760 2844 {}
N 29962 0 29962 2844 {}
N 30724 76 30724 2844 {}
N 30770 0 30770 2844 {}
N 30972 0 30972 2844 {}
N 31174 0 31174 2844 {}
N 31936 76 31936 2844 {}
N 31982 0 31982 2844 {}
N 32184 0 32184 2844 {}
N 32386 0 32386 2844 {}
N 33148 76 33148 2844 {}
N 33194 0 33194 2844 {}
N 33396 0 33396 2844 {}
N 33598 0 33598 2844 {}
N 34360 76 34360 2844 {}
N 34406 0 34406 2844 {}
N 34608 0 34608 2844 {}
N 34810 0 34810 2844 {}
N 35572 76 35572 2844 {}
N 35618 0 35618 2844 {}
N 35820 0 35820 2844 {}
N 36022 0 36022 2844 {}
N 36784 76 36784 2844 {}
N 36830 0 36830 2844 {}
N 37032 0 37032 2844 {}
N 37234 0 37234 2844 {}
N 37996 76 37996 2844 {}
N 38042 0 38042 2844 {}
N 38244 0 38244 2844 {}
N 38446 0 38446 2844 {}
N 39208 76 39208 2844 {}
N 39254 0 39254 2844 {}
N 39456 0 39456 2844 {}
N 39658 0 39658 2844 {}
N 40420 76 40420 2844 {}
N 40466 0 40466 2844 {}
N 40668 0 40668 2844 {}
N 40870 0 40870 2844 {}
N 41632 76 41632 2844 {}
N 41678 0 41678 2844 {}
N 41880 0 41880 2844 {}
N 42082 0 42082 2844 {}
N 42844 76 42844 2844 {}
N 42890 0 42890 2844 {}
N 43092 0 43092 2844 {}
N 43294 0 43294 2844 {}
N 44056 76 44056 2844 {}
N 44102 0 44102 2844 {}
N 44304 0 44304 2844 {}
N 44506 0 44506 2844 {}
N 45268 76 45268 2844 {}
N 45314 0 45314 2844 {}
N 45516 0 45516 2844 {}
N 45718 0 45718 2844 {}
N 46480 76 46480 2844 {}
N 46526 0 46526 2844 {}
N 46728 0 46728 2844 {}
N 46930 0 46930 2844 {}
N 47692 76 47692 2844 {}
N 47738 0 47738 2844 {}
N 48096 76 48096 2844 {}
N 48142 0 48142 2844 {}
N 48500 76 48500 2844 {}
N 48546 0 48546 2844 {}
N 48904 76 48904 2844 {}
N 48950 0 48950 2844 {}
N 49308 76 49308 2844 {}
N 49354 0 49354 2844 {}
N 49556 0 49556 2844 {}
N 49758 0 49758 2844 {}
N 50520 76 50520 2844 {}
N 50566 0 50566 2844 {}
N 50768 0 50768 2844 {}
N 50970 0 50970 2844 {}
N 51732 76 51732 2844 {}
N 51778 0 51778 2844 {}
N 51980 0 51980 2844 {}
N 52182 0 52182 2844 {}
N 52944 76 52944 2844 {}
N 52990 0 52990 2844 {}
N 53192 0 53192 2844 {}
N 53394 0 53394 2844 {}
N 54156 76 54156 2844 {}
N 54202 0 54202 2844 {}
N 54404 0 54404 2844 {}
N 54606 0 54606 2844 {}
N 55368 76 55368 2844 {}
N 55414 0 55414 2844 {}
N 55616 0 55616 2844 {}
N 55818 0 55818 2844 {}
N 222 -76 222 -6492 {}
N 268 0 268 -6492 {}
N 626 -76 626 -6492 {}
N 672 0 672 -6492 {}
N 1030 -76 1030 -6492 {}
N 1076 0 1076 -6492 {}
N 1434 -76 1434 -6492 {}
N 1480 0 1480 -6492 {}
N 1550 0 1550 -6492 {}
N 2156 0 2156 -6492 {}
N 2242 -76 2242 -6492 {}
N 2288 0 2288 -6492 {}
N 2444 -76 2444 -6492 {}
N 2490 0 2490 -6492 {}
N 2646 -76 2646 -6492 {}
N 2692 0 2692 -6492 {}
N 3166 0 3166 -6492 {}
N 3454 -76 3454 -6492 {}
N 3500 0 3500 -6492 {}
N 3656 -76 3656 -6492 {}
N 3702 0 3702 -6492 {}
N 3772 0 3772 -6492 {}
N 3858 -76 3858 -6492 {}
N 3904 0 3904 -6492 {}
N 4666 -76 4666 -6492 {}
N 4712 0 4712 -6492 {}
N 4868 -76 4868 -6492 {}
N 4914 0 4914 -6492 {}
N 5070 -76 5070 -6492 {}
N 5116 0 5116 -6492 {}
N 5388 0 5388 -6492 {}
N 5878 -76 5878 -6492 {}
N 5924 0 5924 -6492 {}
N 5994 0 5994 -6492 {}
N 6080 -76 6080 -6492 {}
N 6126 0 6126 -6492 {}
N 6282 -76 6282 -6492 {}
N 6328 0 6328 -6492 {}
N 6398 0 6398 -6492 {}
N 7004 0 7004 -6492 {}
N 7090 -76 7090 -6492 {}
N 7136 0 7136 -6492 {}
N 7292 -76 7292 -6492 {}
N 7338 0 7338 -6492 {}
N 7494 -76 7494 -6492 {}
N 7540 0 7540 -6492 {}
N 8014 0 8014 -6492 {}
N 8302 -76 8302 -6492 {}
N 8348 0 8348 -6492 {}
N 8504 -76 8504 -6492 {}
N 8550 0 8550 -6492 {}
N 8620 0 8620 -6492 {}
N 8706 -76 8706 -6492 {}
N 8752 0 8752 -6492 {}
N 9110 -76 9110 -6492 {}
N 9156 0 9156 -6492 {}
N 9514 -76 9514 -6492 {}
N 9560 0 9560 -6492 {}
N 9918 -76 9918 -6492 {}
N 9964 0 9964 -6492 {}
N 10322 -76 10322 -6492 {}
N 10368 0 10368 -6492 {}
N 10438 0 10438 -6492 {}
N 11044 0 11044 -6492 {}
N 11130 -76 11130 -6492 {}
N 11176 0 11176 -6492 {}
N 11332 -76 11332 -6492 {}
N 11378 0 11378 -6492 {}
N 11534 -76 11534 -6492 {}
N 11580 0 11580 -6492 {}
N 12054 0 12054 -6492 {}
N 12342 -76 12342 -6492 {}
N 12388 0 12388 -6492 {}
N 12544 -76 12544 -6492 {}
N 12590 0 12590 -6492 {}
N 12660 0 12660 -6492 {}
N 12746 -76 12746 -6492 {}
N 12792 0 12792 -6492 {}
N 13554 -76 13554 -6492 {}
N 13600 0 13600 -6492 {}
N 13756 -76 13756 -6492 {}
N 13802 0 13802 -6492 {}
N 13958 -76 13958 -6492 {}
N 14004 0 14004 -6492 {}
N 14276 0 14276 -6492 {}
N 14766 -76 14766 -6492 {}
N 14812 0 14812 -6492 {}
N 14882 0 14882 -6492 {}
N 14968 -76 14968 -6492 {}
N 15014 0 15014 -6492 {}
N 15170 -76 15170 -6492 {}
N 15216 0 15216 -6492 {}
N 15286 0 15286 -6492 {}
N 15892 0 15892 -6492 {}
N 15978 -76 15978 -6492 {}
N 16024 0 16024 -6492 {}
N 16180 -76 16180 -6492 {}
N 16226 0 16226 -6492 {}
N 16382 -76 16382 -6492 {}
N 16428 0 16428 -6492 {}
N 16902 0 16902 -6492 {}
N 17190 -76 17190 -6492 {}
N 17236 0 17236 -6492 {}
N 17392 -76 17392 -6492 {}
N 17438 0 17438 -6492 {}
N 17508 0 17508 -6492 {}
N 17594 -76 17594 -6492 {}
N 17640 0 17640 -6492 {}
N 18114 0 18114 -6492 {}
N 18402 -76 18402 -6492 {}
N 18448 0 18448 -6492 {}
N 18604 -76 18604 -6492 {}
N 18650 0 18650 -6492 {}
N 18720 0 18720 -6492 {}
N 18806 -76 18806 -6492 {}
N 18852 0 18852 -6492 {}
N 19210 -76 19210 -6492 {}
N 19256 0 19256 -6492 {}
N 19730 0 19730 -6492 {}
N 20018 -76 20018 -6492 {}
N 20064 0 20064 -6492 {}
N 20220 -76 20220 -6492 {}
N 20266 0 20266 -6492 {}
N 20336 0 20336 -6492 {}
N 20422 -76 20422 -6492 {}
N 20468 0 20468 -6492 {}
N 20826 -76 20826 -6492 {}
N 20872 0 20872 -6492 {}
N 21346 0 21346 -6492 {}
N 21634 -76 21634 -6492 {}
N 21680 0 21680 -6492 {}
N 21836 -76 21836 -6492 {}
N 21882 0 21882 -6492 {}
N 21952 0 21952 -6492 {}
N 22038 -76 22038 -6492 {}
N 22084 0 22084 -6492 {}
N 22558 0 22558 -6492 {}
N 22846 -76 22846 -6492 {}
N 22892 0 22892 -6492 {}
N 23048 -76 23048 -6492 {}
N 23094 0 23094 -6492 {}
N 23164 0 23164 -6492 {}
N 23250 -76 23250 -6492 {}
N 23296 0 23296 -6492 {}
N 23770 0 23770 -6492 {}
N 24058 -76 24058 -6492 {}
N 24104 0 24104 -6492 {}
N 24260 -76 24260 -6492 {}
N 24306 0 24306 -6492 {}
N 24376 0 24376 -6492 {}
N 24462 -76 24462 -6492 {}
N 24508 0 24508 -6492 {}
N 24982 0 24982 -6492 {}
N 25270 -76 25270 -6492 {}
N 25316 0 25316 -6492 {}
N 25472 -76 25472 -6492 {}
N 25518 0 25518 -6492 {}
N 25588 0 25588 -6492 {}
N 25674 -76 25674 -6492 {}
N 25720 0 25720 -6492 {}
N 25790 0 25790 -6492 {}
N 26396 0 26396 -6492 {}
N 26482 -76 26482 -6492 {}
N 26528 0 26528 -6492 {}
N 26684 -76 26684 -6492 {}
N 26730 0 26730 -6492 {}
N 26886 -76 26886 -6492 {}
N 26932 0 26932 -6492 {}
N 27406 0 27406 -6492 {}
N 27694 -76 27694 -6492 {}
N 27740 0 27740 -6492 {}
N 27896 -76 27896 -6492 {}
N 27942 0 27942 -6492 {}
N 28012 0 28012 -6492 {}
N 28098 -76 28098 -6492 {}
N 28144 0 28144 -6492 {}
N 28906 -76 28906 -6492 {}
N 28952 0 28952 -6492 {}
N 29108 -76 29108 -6492 {}
N 29154 0 29154 -6492 {}
N 29310 -76 29310 -6492 {}
N 29356 0 29356 -6492 {}
N 29628 0 29628 -6492 {}
N 30118 -76 30118 -6492 {}
N 30164 0 30164 -6492 {}
N 30234 0 30234 -6492 {}
N 30320 -76 30320 -6492 {}
N 30366 0 30366 -6492 {}
N 30522 -76 30522 -6492 {}
N 30568 0 30568 -6492 {}
N 30638 0 30638 -6492 {}
N 31244 0 31244 -6492 {}
N 31330 -76 31330 -6492 {}
N 31376 0 31376 -6492 {}
N 31532 -76 31532 -6492 {}
N 31578 0 31578 -6492 {}
N 31734 -76 31734 -6492 {}
N 31780 0 31780 -6492 {}
N 32254 0 32254 -6492 {}
N 32542 -76 32542 -6492 {}
N 32588 0 32588 -6492 {}
N 32744 -76 32744 -6492 {}
N 32790 0 32790 -6492 {}
N 32860 0 32860 -6492 {}
N 32946 -76 32946 -6492 {}
N 32992 0 32992 -6492 {}
N 33062 0 33062 -6492 {}
N 33668 0 33668 -6492 {}
N 33754 -76 33754 -6492 {}
N 33800 0 33800 -6492 {}
N 33956 -76 33956 -6492 {}
N 34002 0 34002 -6492 {}
N 34158 -76 34158 -6492 {}
N 34204 0 34204 -6492 {}
N 34678 0 34678 -6492 {}
N 34966 -76 34966 -6492 {}
N 35012 0 35012 -6492 {}
N 35168 -76 35168 -6492 {}
N 35214 0 35214 -6492 {}
N 35284 0 35284 -6492 {}
N 35370 -76 35370 -6492 {}
N 35416 0 35416 -6492 {}
N 36178 -76 36178 -6492 {}
N 36224 0 36224 -6492 {}
N 36380 -76 36380 -6492 {}
N 36426 0 36426 -6492 {}
N 36582 -76 36582 -6492 {}
N 36628 0 36628 -6492 {}
N 36900 0 36900 -6492 {}
N 37390 -76 37390 -6492 {}
N 37436 0 37436 -6492 {}
N 37506 0 37506 -6492 {}
N 37592 -76 37592 -6492 {}
N 37638 0 37638 -6492 {}
N 37794 -76 37794 -6492 {}
N 37840 0 37840 -6492 {}
N 37910 0 37910 -6492 {}
N 38516 0 38516 -6492 {}
N 38602 -76 38602 -6492 {}
N 38648 0 38648 -6492 {}
N 38804 -76 38804 -6492 {}
N 38850 0 38850 -6492 {}
N 39006 -76 39006 -6492 {}
N 39052 0 39052 -6492 {}
N 39526 0 39526 -6492 {}
N 39814 -76 39814 -6492 {}
N 39860 0 39860 -6492 {}
N 40016 -76 40016 -6492 {}
N 40062 0 40062 -6492 {}
N 40132 0 40132 -6492 {}
N 40218 -76 40218 -6492 {}
N 40264 0 40264 -6492 {}
N 40334 0 40334 -6492 {}
N 40940 0 40940 -6492 {}
N 41026 -76 41026 -6492 {}
N 41072 0 41072 -6492 {}
N 41228 -76 41228 -6492 {}
N 41274 0 41274 -6492 {}
N 41430 -76 41430 -6492 {}
N 41476 0 41476 -6492 {}
N 41950 0 41950 -6492 {}
N 42238 -76 42238 -6492 {}
N 42284 0 42284 -6492 {}
N 42440 -76 42440 -6492 {}
N 42486 0 42486 -6492 {}
N 42556 0 42556 -6492 {}
N 42642 -76 42642 -6492 {}
N 42688 0 42688 -6492 {}
N 43450 -76 43450 -6492 {}
N 43496 0 43496 -6492 {}
N 43652 -76 43652 -6492 {}
N 43698 0 43698 -6492 {}
N 43854 -76 43854 -6492 {}
N 43900 0 43900 -6492 {}
N 44172 0 44172 -6492 {}
N 44662 -76 44662 -6492 {}
N 44708 0 44708 -6492 {}
N 44778 0 44778 -6492 {}
N 44864 -76 44864 -6492 {}
N 44910 0 44910 -6492 {}
N 45066 -76 45066 -6492 {}
N 45112 0 45112 -6492 {}
N 45182 0 45182 -6492 {}
N 45788 0 45788 -6492 {}
N 45874 -76 45874 -6492 {}
N 45920 0 45920 -6492 {}
N 46076 -76 46076 -6492 {}
N 46122 0 46122 -6492 {}
N 46278 -76 46278 -6492 {}
N 46324 0 46324 -6492 {}
N 46798 0 46798 -6492 {}
N 47086 -76 47086 -6492 {}
N 47132 0 47132 -6492 {}
N 47288 -76 47288 -6492 {}
N 47334 0 47334 -6492 {}
N 47404 0 47404 -6492 {}
N 47490 -76 47490 -6492 {}
N 47536 0 47536 -6492 {}
N 47894 -76 47894 -6492 {}
N 47940 0 47940 -6492 {}
N 48298 -76 48298 -6492 {}
N 48344 0 48344 -6492 {}
N 48702 -76 48702 -6492 {}
N 48748 0 48748 -6492 {}
N 49106 -76 49106 -6492 {}
N 49152 0 49152 -6492 {}
N 49222 0 49222 -6492 {}
N 49828 0 49828 -6492 {}
N 49914 -76 49914 -6492 {}
N 49960 0 49960 -6492 {}
N 50116 -76 50116 -6492 {}
N 50162 0 50162 -6492 {}
N 50318 -76 50318 -6492 {}
N 50364 0 50364 -6492 {}
N 50838 0 50838 -6492 {}
N 51126 -76 51126 -6492 {}
N 51172 0 51172 -6492 {}
N 51328 -76 51328 -6492 {}
N 51374 0 51374 -6492 {}
N 51444 0 51444 -6492 {}
N 51530 -76 51530 -6492 {}
N 51576 0 51576 -6492 {}
N 52338 -76 52338 -6492 {}
N 52384 0 52384 -6492 {}
N 52540 -76 52540 -6492 {}
N 52586 0 52586 -6492 {}
N 52742 -76 52742 -6492 {}
N 52788 0 52788 -6492 {}
N 53060 0 53060 -6492 {}
N 53550 -76 53550 -6492 {}
N 53596 0 53596 -6492 {}
N 53666 0 53666 -6492 {}
N 53752 -76 53752 -6492 {}
N 53798 0 53798 -6492 {}
N 53954 -76 53954 -6492 {}
N 54000 0 54000 -6492 {}
N 54070 0 54070 -6492 {}
N 54676 0 54676 -6492 {}
N 54762 -76 54762 -6492 {}
N 54808 0 54808 -6492 {}
N 54964 -76 54964 -6492 {}
N 55010 0 55010 -6492 {}
N 55166 -76 55166 -6492 {}
N 55212 0 55212 -6492 {}
N 55686 0 55686 -6492 {}
N 55974 -76 55974 -6492 {}
N 56020 0 56020 -6492 {}
N 56176 -76 56176 -6492 {}
N 56222 0 56222 -6492 {}
N 56292 0 56292 -6492 {}
N 56378 -76 56378 -6492 {}
N 56424 0 56424 -6492 {}
N 424 -76 424 -180 {}
N 742 0 742 -180 {}
N 944 0 944 -180 {}
N 828 -76 828 -244 {}
N 1146 0 1146 -244 {}
N 1348 0 1348 -244 {}
N 1232 -76 1232 -308 {}
N 5590 0 5590 -308 {}
N 6196 0 6196 -308 {}
N 1636 -76 1636 -372 {}
N 1838 -76 1838 -436 {}
N 1752 0 1752 180 {}
N 2358 0 2358 180 {}
N 4378 0 4378 180 {}
N 4984 0 4984 180 {}
N 5878 76 5878 180 {}
N 6080 76 6080 180 {}
N 6282 76 6282 180 {}
N 2242 76 2242 244 {}
N 2444 76 2444 244 {}
N 2646 76 2646 244 {}
N 2762 0 2762 244 {}
N 3368 0 3368 244 {}
N 1954 0 1954 308 {}
N 2560 0 2560 308 {}
N 3454 76 3454 308 {}
N 3656 76 3656 308 {}
N 3858 76 3858 308 {}
N 3974 0 3974 308 {}
N 4580 0 4580 308 {}
N 6600 0 6600 308 {}
N 7206 0 7206 308 {}
N 2848 -76 2848 -500 {}
N 3050 -76 3050 -564 {}
N 2964 0 2964 -628 {}
N 3570 0 3570 -628 {}
N 4176 0 4176 -628 {}
N 4782 0 4782 -628 {}
N 4060 -76 4060 -692 {}
N 4262 -76 4262 -756 {}
N 4666 76 4666 372 {}
N 4868 76 4868 372 {}
N 5070 76 5070 372 {}
N 5186 0 5186 372 {}
N 5792 0 5792 372 {}
N 7812 0 7812 372 {}
N 8418 0 8418 372 {}
N 5272 -76 5272 -820 {}
N 5474 -76 5474 -884 {}
N 6484 -76 6484 -948 {}
N 6686 -76 6686 -1012 {}
N 7090 76 7090 436 {}
N 7292 76 7292 436 {}
N 7494 76 7494 436 {}
N 7610 0 7610 436 {}
N 8216 0 8216 436 {}
N 11852 0 11852 436 {}
N 12458 0 12458 436 {}
N 13064 0 13064 436 {}
N 13670 0 13670 436 {}
N 7696 -76 7696 -1076 {}
N 7898 -76 7898 -1140 {}
N 8908 -76 8908 -1204 {}
N 9226 0 9226 -1204 {}
N 9428 0 9428 -1204 {}
N 8822 0 8822 500 {}
N 9024 0 9024 500 {}
N 15690 0 15690 500 {}
N 16296 0 16296 500 {}
N 17190 76 17190 500 {}
N 17392 76 17392 500 {}
N 17594 76 17594 500 {}
N 9312 -76 9312 -1268 {}
N 9630 0 9630 -1268 {}
N 9832 0 9832 -1268 {}
N 9716 -76 9716 -1332 {}
N 10034 0 10034 -1332 {}
N 10236 0 10236 -1332 {}
N 10120 -76 10120 -1396 {}
N 14478 0 14478 -1396 {}
N 15084 0 15084 -1396 {}
N 10524 -76 10524 -1460 {}
N 10726 -76 10726 -1524 {}
N 10640 0 10640 564 {}
N 11246 0 11246 564 {}
N 13266 0 13266 564 {}
N 13872 0 13872 564 {}
N 14766 76 14766 564 {}
N 14968 76 14968 564 {}
N 15170 76 15170 564 {}
N 11130 76 11130 628 {}
N 11332 76 11332 628 {}
N 11534 76 11534 628 {}
N 11650 0 11650 628 {}
N 12256 0 12256 628 {}
N 10842 0 10842 692 {}
N 11448 0 11448 692 {}
N 12342 76 12342 692 {}
N 12544 76 12544 692 {}
N 12746 76 12746 692 {}
N 12862 0 12862 692 {}
N 13468 0 13468 692 {}
N 15488 0 15488 692 {}
N 16094 0 16094 692 {}
N 11736 -76 11736 -1588 {}
N 11938 -76 11938 -1652 {}
N 12948 -76 12948 -1716 {}
N 13150 -76 13150 -1780 {}
N 13554 76 13554 756 {}
N 13756 76 13756 756 {}
N 13958 76 13958 756 {}
N 14074 0 14074 756 {}
N 14680 0 14680 756 {}
N 16700 0 16700 756 {}
N 17306 0 17306 756 {}
N 14160 -76 14160 -1844 {}
N 14362 -76 14362 -1908 {}
N 15372 -76 15372 -1972 {}
N 15574 -76 15574 -2036 {}
N 15978 76 15978 820 {}
N 16180 76 16180 820 {}
N 16382 76 16382 820 {}
N 16498 0 16498 820 {}
N 17104 0 17104 820 {}
N 27204 0 27204 820 {}
N 27810 0 27810 820 {}
N 28416 0 28416 820 {}
N 29022 0 29022 820 {}
N 34476 0 34476 820 {}
N 35082 0 35082 820 {}
N 35688 0 35688 820 {}
N 36294 0 36294 820 {}
N 41748 0 41748 820 {}
N 42354 0 42354 820 {}
N 42960 0 42960 820 {}
N 43566 0 43566 820 {}
N 16584 -76 16584 -2100 {}
N 16786 -76 16786 -2164 {}
N 17796 -76 17796 -2228 {}
N 17710 0 17710 884 {}
N 18316 0 18316 884 {}
N 31042 0 31042 884 {}
N 31648 0 31648 884 {}
N 32542 76 32542 884 {}
N 32744 76 32744 884 {}
N 32946 76 32946 884 {}
N 17998 -76 17998 -2292 {}
N 17912 0 17912 948 {}
N 18518 0 18518 948 {}
N 45586 0 45586 948 {}
N 46192 0 46192 948 {}
N 47086 76 47086 948 {}
N 47288 76 47288 948 {}
N 47490 76 47490 948 {}
N 18402 76 18402 1012 {}
N 18604 76 18604 1012 {}
N 18806 76 18806 1012 {}
N 18922 0 18922 1012 {}
N 19124 0 19124 1012 {}
N 19008 -76 19008 -2356 {}
N 29830 0 29830 -2356 {}
N 30436 0 30436 -2356 {}
N 19412 -76 19412 -2420 {}
N 19326 0 19326 1076 {}
N 19932 0 19932 1076 {}
N 20942 0 20942 1076 {}
N 21548 0 21548 1076 {}
N 22154 0 22154 1076 {}
N 22760 0 22760 1076 {}
N 31330 76 31330 1076 {}
N 31532 76 31532 1076 {}
N 31734 76 31734 1076 {}
N 31850 0 31850 1076 {}
N 32456 0 32456 1076 {}
N 19614 -76 19614 -2484 {}
N 19528 0 19528 1140 {}
N 20134 0 20134 1140 {}
N 21144 0 21144 1140 {}
N 21750 0 21750 1140 {}
N 23366 0 23366 1140 {}
N 23972 0 23972 1140 {}
N 38602 76 38602 1140 {}
N 38804 76 38804 1140 {}
N 39006 76 39006 1140 {}
N 39122 0 39122 1140 {}
N 39728 0 39728 1140 {}
N 20018 76 20018 1204 {}
N 20220 76 20220 1204 {}
N 20422 76 20422 1204 {}
N 20538 0 20538 1204 {}
N 20740 0 20740 1204 {}
N 20624 -76 20624 -2548 {}
N 44374 0 44374 -2548 {}
N 44980 0 44980 -2548 {}
N 21028 -76 21028 -2612 {}
N 21230 -76 21230 -2676 {}
N 21634 76 21634 1268 {}
N 21836 76 21836 1268 {}
N 22038 76 22038 1268 {}
N 22356 0 22356 1268 {}
N 22962 0 22962 1268 {}
N 23568 0 23568 1268 {}
N 24174 0 24174 1268 {}
N 22240 -76 22240 -2740 {}
N 22442 -76 22442 -2804 {}
N 22846 76 22846 1332 {}
N 23048 76 23048 1332 {}
N 23250 76 23250 1332 {}
N 24578 0 24578 1332 {}
N 25184 0 25184 1332 {}
N 23452 -76 23452 -2868 {}
N 23654 -76 23654 -2932 {}
N 24058 76 24058 1396 {}
N 24260 76 24260 1396 {}
N 24462 76 24462 1396 {}
N 24780 0 24780 1396 {}
N 25386 0 25386 1396 {}
N 24664 -76 24664 -2996 {}
N 24866 -76 24866 -3060 {}
N 25270 76 25270 1460 {}
N 25472 76 25472 1460 {}
N 25674 76 25674 1460 {}
N 37102 0 37102 1460 {}
N 37708 0 37708 1460 {}
N 25876 -76 25876 -3124 {}
N 26078 -76 26078 -3188 {}
N 25992 0 25992 1524 {}
N 26598 0 26598 1524 {}
N 28618 0 28618 1524 {}
N 29224 0 29224 1524 {}
N 30118 76 30118 1524 {}
N 30320 76 30320 1524 {}
N 30522 76 30522 1524 {}
N 26482 76 26482 1588 {}
N 26684 76 26684 1588 {}
N 26886 76 26886 1588 {}
N 27002 0 27002 1588 {}
N 27608 0 27608 1588 {}
N 26194 0 26194 1652 {}
N 26800 0 26800 1652 {}
N 27694 76 27694 1652 {}
N 27896 76 27896 1652 {}
N 28098 76 28098 1652 {}
N 28214 0 28214 1652 {}
N 28820 0 28820 1652 {}
N 30840 0 30840 1652 {}
N 31446 0 31446 1652 {}
N 27088 -76 27088 -3252 {}
N 27290 -76 27290 -3316 {}
N 28300 -76 28300 -3380 {}
N 28502 -76 28502 -3444 {}
N 28906 76 28906 1716 {}
N 29108 76 29108 1716 {}
N 29310 76 29310 1716 {}
N 29426 0 29426 1716 {}
N 30032 0 30032 1716 {}
N 32052 0 32052 1716 {}
N 32658 0 32658 1716 {}
N 29512 -76 29512 -3508 {}
N 29714 -76 29714 -3572 {}
N 30724 -76 30724 -3636 {}
N 30926 -76 30926 -3700 {}
N 31936 -76 31936 -3764 {}
N 32138 -76 32138 -3828 {}
N 33148 -76 33148 -3892 {}
N 33350 -76 33350 -3956 {}
N 33264 0 33264 1780 {}
N 33870 0 33870 1780 {}
N 35890 0 35890 1780 {}
N 36496 0 36496 1780 {}
N 37390 76 37390 1780 {}
N 37592 76 37592 1780 {}
N 37794 76 37794 1780 {}
N 33754 76 33754 1844 {}
N 33956 76 33956 1844 {}
N 34158 76 34158 1844 {}
N 34274 0 34274 1844 {}
N 34880 0 34880 1844 {}
N 33466 0 33466 1908 {}
N 34072 0 34072 1908 {}
N 34966 76 34966 1908 {}
N 35168 76 35168 1908 {}
N 35370 76 35370 1908 {}
N 35486 0 35486 1908 {}
N 36092 0 36092 1908 {}
N 38112 0 38112 1908 {}
N 38718 0 38718 1908 {}
N 34360 -76 34360 -4020 {}
N 34562 -76 34562 -4084 {}
N 35572 -76 35572 -4148 {}
N 35774 -76 35774 -4212 {}
N 36178 76 36178 1972 {}
N 36380 76 36380 1972 {}
N 36582 76 36582 1972 {}
N 36698 0 36698 1972 {}
N 37304 0 37304 1972 {}
N 39324 0 39324 1972 {}
N 39930 0 39930 1972 {}
N 36784 -76 36784 -4276 {}
N 36986 -76 36986 -4340 {}
N 37996 -76 37996 -4404 {}
N 38198 -76 38198 -4468 {}
N 38314 0 38314 2036 {}
N 38920 0 38920 2036 {}
N 39814 76 39814 2036 {}
N 40016 76 40016 2036 {}
N 40218 76 40218 2036 {}
N 39208 -76 39208 -4532 {}
N 39410 -76 39410 -4596 {}
N 40420 -76 40420 -4660 {}
N 40622 -76 40622 -4724 {}
N 40536 0 40536 2100 {}
N 41142 0 41142 2100 {}
N 43162 0 43162 2100 {}
N 43768 0 43768 2100 {}
N 44662 76 44662 2100 {}
N 44864 76 44864 2100 {}
N 45066 76 45066 2100 {}
N 41026 76 41026 2164 {}
N 41228 76 41228 2164 {}
N 41430 76 41430 2164 {}
N 41546 0 41546 2164 {}
N 42152 0 42152 2164 {}
N 40738 0 40738 2228 {}
N 41344 0 41344 2228 {}
N 42238 76 42238 2228 {}
N 42440 76 42440 2228 {}
N 42642 76 42642 2228 {}
N 42758 0 42758 2228 {}
N 43364 0 43364 2228 {}
N 45384 0 45384 2228 {}
N 45990 0 45990 2228 {}
N 41632 -76 41632 -4788 {}
N 41834 -76 41834 -4852 {}
N 42844 -76 42844 -4916 {}
N 43046 -76 43046 -4980 {}
N 43450 76 43450 2292 {}
N 43652 76 43652 2292 {}
N 43854 76 43854 2292 {}
N 43970 0 43970 2292 {}
N 44576 0 44576 2292 {}
N 46596 0 46596 2292 {}
N 47202 0 47202 2292 {}
N 44056 -76 44056 -5044 {}
N 44258 -76 44258 -5108 {}
N 45268 -76 45268 -5172 {}
N 45470 -76 45470 -5236 {}
N 45874 76 45874 2356 {}
N 46076 76 46076 2356 {}
N 46278 76 46278 2356 {}
N 46394 0 46394 2356 {}
N 47000 0 47000 2356 {}
N 50636 0 50636 2356 {}
N 51242 0 51242 2356 {}
N 51848 0 51848 2356 {}
N 52454 0 52454 2356 {}
N 46480 -76 46480 -5300 {}
N 46682 -76 46682 -5364 {}
N 47692 -76 47692 -5428 {}
N 48010 0 48010 -5428 {}
N 48212 0 48212 -5428 {}
N 47606 0 47606 2420 {}
N 47808 0 47808 2420 {}
N 54474 0 54474 2420 {}
N 55080 0 55080 2420 {}
N 55974 76 55974 2420 {}
N 56176 76 56176 2420 {}
N 56378 76 56378 2420 {}
N 48096 -76 48096 -5492 {}
N 48414 0 48414 -5492 {}
N 48616 0 48616 -5492 {}
N 48500 -76 48500 -5556 {}
N 48818 0 48818 -5556 {}
N 49020 0 49020 -5556 {}
N 48904 -76 48904 -5620 {}
N 53262 0 53262 -5620 {}
N 53868 0 53868 -5620 {}
N 49308 -76 49308 -5684 {}
N 49510 -76 49510 -5748 {}
N 49424 0 49424 2484 {}
N 50030 0 50030 2484 {}
N 52050 0 52050 2484 {}
N 52656 0 52656 2484 {}
N 53550 76 53550 2484 {}
N 53752 76 53752 2484 {}
N 53954 76 53954 2484 {}
N 49914 76 49914 2548 {}
N 50116 76 50116 2548 {}
N 50318 76 50318 2548 {}
N 50434 0 50434 2548 {}
N 51040 0 51040 2548 {}
N 49626 0 49626 2612 {}
N 50232 0 50232 2612 {}
N 51126 76 51126 2612 {}
N 51328 76 51328 2612 {}
N 51530 76 51530 2612 {}
N 51646 0 51646 2612 {}
N 52252 0 52252 2612 {}
N 54272 0 54272 2612 {}
N 54878 0 54878 2612 {}
N 50520 -76 50520 -5812 {}
N 50722 -76 50722 -5876 {}
N 51732 -76 51732 -5940 {}
N 51934 -76 51934 -6004 {}
N 52338 76 52338 2676 {}
N 52540 76 52540 2676 {}
N 52742 76 52742 2676 {}
N 52858 0 52858 2676 {}
N 53464 0 53464 2676 {}
N 55484 0 55484 2676 {}
N 56090 0 56090 2676 {}
N 52944 -76 52944 -6068 {}
N 53146 -76 53146 -6132 {}
N 54156 -76 54156 -6196 {}
N 54358 -76 54358 -6260 {}
N 54762 76 54762 2740 {}
N 54964 76 54964 2740 {}
N 55166 76 55166 2740 {}
N 55282 0 55282 2740 {}
N 55888 0 55888 2740 {}
N 55368 -76 55368 -6324 {}
N 55570 -76 55570 -6388 {}
N 222 76 256 76 {}
N 256 76 256 -116 {}
N 8100 -76 8134 -76 {}
N 8134 -76 8134 116 {}
N 626 76 660 76 {}
N 660 76 660 -180 {}
N 1030 76 1064 76 {}
N 1064 76 1064 -244 {}
N 1434 76 1468 76 {}
N 1468 76 1468 -308 {}
N 1838 76 1872 76 {}
N 1872 76 1872 -372 {}
N 2040 76 2074 76 {}
N 2074 76 2074 -436 {}
N 5676 -76 5710 -76 {}
N 5710 -76 5710 180 {}
N 2040 -76 2006 -76 {}
N 2006 -76 2006 244 {}
N 3252 -76 3286 -76 {}
N 3286 -76 3286 308 {}
N 3050 76 3084 76 {}
N 3084 76 3084 -500 {}
N 3252 76 3218 76 {}
N 3218 76 3218 -564 {}
N 4262 76 4296 76 {}
N 4296 76 4296 -692 {}
N 4464 76 4498 76 {}
N 4498 76 4498 -756 {}
N 4464 -76 4430 -76 {}
N 4430 -76 4430 372 {}
N 5474 76 5508 76 {}
N 5508 76 5508 -820 {}
N 5676 76 5642 76 {}
N 5642 76 5642 -884 {}
N 6686 76 6720 76 {}
N 6720 76 6720 -948 {}
N 6888 76 6922 76 {}
N 6922 76 6922 -1012 {}
N 6888 -76 6854 -76 {}
N 6854 -76 6854 436 {}
N 7898 76 7932 76 {}
N 7932 76 7932 -1076 {}
N 8100 76 8066 76 {}
N 8066 76 8066 -1140 {}
N 9110 76 9144 76 {}
N 9144 76 9144 -1204 {}
N 16988 -76 17022 -76 {}
N 17022 -76 17022 500 {}
N 9514 76 9548 76 {}
N 9548 76 9548 -1268 {}
N 9918 76 9952 76 {}
N 9952 76 9952 -1332 {}
N 10322 76 10356 76 {}
N 10356 76 10356 -1396 {}
N 10726 76 10760 76 {}
N 10760 76 10760 -1460 {}
N 10928 76 10962 76 {}
N 10962 76 10962 -1524 {}
N 14564 -76 14598 -76 {}
N 14598 -76 14598 564 {}
N 10928 -76 10894 -76 {}
N 10894 -76 10894 628 {}
N 12140 -76 12174 -76 {}
N 12174 -76 12174 692 {}
N 11938 76 11972 76 {}
N 11972 76 11972 -1588 {}
N 12140 76 12106 76 {}
N 12106 76 12106 -1652 {}
N 13150 76 13184 76 {}
N 13184 76 13184 -1716 {}
N 13352 76 13386 76 {}
N 13386 76 13386 -1780 {}
N 13352 -76 13318 -76 {}
N 13318 -76 13318 756 {}
N 14362 76 14396 76 {}
N 14396 76 14396 -1844 {}
N 14564 76 14530 76 {}
N 14530 76 14530 -1908 {}
N 15574 76 15608 76 {}
N 15608 76 15608 -1972 {}
N 15776 76 15810 76 {}
N 15810 76 15810 -2036 {}
N 15776 -76 15742 -76 {}
N 15742 -76 15742 820 {}
N 16786 76 16820 76 {}
N 16820 76 16820 -2100 {}
N 16988 76 16954 76 {}
N 16954 76 16954 -2164 {}
N 17998 76 18032 76 {}
N 18032 76 18032 -2228 {}
N 32340 -76 32374 -76 {}
N 32374 -76 32374 884 {}
N 18200 76 18234 76 {}
N 18234 76 18234 -2292 {}
N 46884 -76 46918 -76 {}
N 46918 -76 46918 948 {}
N 18200 -76 18166 -76 {}
N 18166 -76 18166 1012 {}
N 19210 76 19244 76 {}
N 19244 76 19244 -2356 {}
N 19614 76 19648 76 {}
N 19648 76 19648 -2420 {}
N 31128 -76 31162 -76 {}
N 31162 -76 31162 1076 {}
N 19816 76 19850 76 {}
N 19850 76 19850 -2484 {}
N 38400 -76 38434 -76 {}
N 38434 -76 38434 1140 {}
N 19816 -76 19782 -76 {}
N 19782 -76 19782 1204 {}
N 20826 76 20860 76 {}
N 20860 76 20860 -2548 {}
N 21230 76 21264 76 {}
N 21264 76 21264 -2612 {}
N 21432 76 21466 76 {}
N 21466 76 21466 -2676 {}
N 21432 -76 21398 -76 {}
N 21398 -76 21398 1268 {}
N 22442 76 22476 76 {}
N 22476 76 22476 -2740 {}
N 22644 76 22678 76 {}
N 22678 76 22678 -2804 {}
N 22644 -76 22610 -76 {}
N 22610 -76 22610 1332 {}
N 23654 76 23688 76 {}
N 23688 76 23688 -2868 {}
N 23856 76 23890 76 {}
N 23890 76 23890 -2932 {}
N 23856 -76 23822 -76 {}
N 23822 -76 23822 1396 {}
N 24866 76 24900 76 {}
N 24900 76 24900 -2996 {}
N 25068 76 25102 76 {}
N 25102 76 25102 -3060 {}
N 25068 -76 25034 -76 {}
N 25034 -76 25034 1460 {}
N 26078 76 26112 76 {}
N 26112 76 26112 -3124 {}
N 26280 76 26314 76 {}
N 26314 76 26314 -3188 {}
N 29916 -76 29950 -76 {}
N 29950 -76 29950 1524 {}
N 26280 -76 26246 -76 {}
N 26246 -76 26246 1588 {}
N 27492 -76 27526 -76 {}
N 27526 -76 27526 1652 {}
N 27290 76 27324 76 {}
N 27324 76 27324 -3252 {}
N 27492 76 27458 76 {}
N 27458 76 27458 -3316 {}
N 28502 76 28536 76 {}
N 28536 76 28536 -3380 {}
N 28704 76 28738 76 {}
N 28738 76 28738 -3444 {}
N 28704 -76 28670 -76 {}
N 28670 -76 28670 1716 {}
N 29714 76 29748 76 {}
N 29748 76 29748 -3508 {}
N 29916 76 29882 76 {}
N 29882 76 29882 -3572 {}
N 30926 76 30960 76 {}
N 30960 76 30960 -3636 {}
N 31128 76 31094 76 {}
N 31094 76 31094 -3700 {}
N 32138 76 32172 76 {}
N 32172 76 32172 -3764 {}
N 32340 76 32306 76 {}
N 32306 76 32306 -3828 {}
N 33350 76 33384 76 {}
N 33384 76 33384 -3892 {}
N 33552 76 33586 76 {}
N 33586 76 33586 -3956 {}
N 37188 -76 37222 -76 {}
N 37222 -76 37222 1780 {}
N 33552 -76 33518 -76 {}
N 33518 -76 33518 1844 {}
N 34764 -76 34798 -76 {}
N 34798 -76 34798 1908 {}
N 34562 76 34596 76 {}
N 34596 76 34596 -4020 {}
N 34764 76 34730 76 {}
N 34730 76 34730 -4084 {}
N 35774 76 35808 76 {}
N 35808 76 35808 -4148 {}
N 35976 76 36010 76 {}
N 36010 76 36010 -4212 {}
N 35976 -76 35942 -76 {}
N 35942 -76 35942 1972 {}
N 36986 76 37020 76 {}
N 37020 76 37020 -4276 {}
N 37188 76 37154 76 {}
N 37154 76 37154 -4340 {}
N 38198 76 38232 76 {}
N 38232 76 38232 -4404 {}
N 38400 76 38366 76 {}
N 38366 76 38366 -4468 {}
N 39612 -76 39646 -76 {}
N 39646 -76 39646 2036 {}
N 39410 76 39444 76 {}
N 39444 76 39444 -4532 {}
N 39612 76 39578 76 {}
N 39578 76 39578 -4596 {}
N 40622 76 40656 76 {}
N 40656 76 40656 -4660 {}
N 40824 76 40858 76 {}
N 40858 76 40858 -4724 {}
N 44460 -76 44494 -76 {}
N 44494 -76 44494 2100 {}
N 40824 -76 40790 -76 {}
N 40790 -76 40790 2164 {}
N 42036 -76 42070 -76 {}
N 42070 -76 42070 2228 {}
N 41834 76 41868 76 {}
N 41868 76 41868 -4788 {}
N 42036 76 42002 76 {}
N 42002 76 42002 -4852 {}
N 43046 76 43080 76 {}
N 43080 76 43080 -4916 {}
N 43248 76 43282 76 {}
N 43282 76 43282 -4980 {}
N 43248 -76 43214 -76 {}
N 43214 -76 43214 2292 {}
N 44258 76 44292 76 {}
N 44292 76 44292 -5044 {}
N 44460 76 44426 76 {}
N 44426 76 44426 -5108 {}
N 45470 76 45504 76 {}
N 45504 76 45504 -5172 {}
N 45672 76 45706 76 {}
N 45706 76 45706 -5236 {}
N 45672 -76 45638 -76 {}
N 45638 -76 45638 2356 {}
N 46682 76 46716 76 {}
N 46716 76 46716 -5300 {}
N 46884 76 46850 76 {}
N 46850 76 46850 -5364 {}
N 47894 76 47928 76 {}
N 47928 76 47928 -5428 {}
N 55772 -76 55806 -76 {}
N 55806 -76 55806 2420 {}
N 48298 76 48332 76 {}
N 48332 76 48332 -5492 {}
N 48702 76 48736 76 {}
N 48736 76 48736 -5556 {}
N 49106 76 49140 76 {}
N 49140 76 49140 -5620 {}
N 49510 76 49544 76 {}
N 49544 76 49544 -5684 {}
N 49712 76 49746 76 {}
N 49746 76 49746 -5748 {}
N 53348 -76 53382 -76 {}
N 53382 -76 53382 2484 {}
N 49712 -76 49678 -76 {}
N 49678 -76 49678 2548 {}
N 50924 -76 50958 -76 {}
N 50958 -76 50958 2612 {}
N 50722 76 50756 76 {}
N 50756 76 50756 -5812 {}
N 50924 76 50890 76 {}
N 50890 76 50890 -5876 {}
N 51934 76 51968 76 {}
N 51968 76 51968 -5940 {}
N 52136 76 52170 76 {}
N 52170 76 52170 -6004 {}
N 52136 -76 52102 -76 {}
N 52102 -76 52102 2676 {}
N 53146 76 53180 76 {}
N 53180 76 53180 -6068 {}
N 53348 76 53314 76 {}
N 53314 76 53314 -6132 {}
N 54358 76 54392 76 {}
N 54392 76 54392 -6196 {}
N 54560 76 54594 76 {}
N 54594 76 54594 -6260 {}
N 54560 -76 54526 -76 {}
N 54526 -76 54526 2740 {}
N 55570 76 55604 76 {}
N 55604 76 55604 -6324 {}
N 55772 76 55738 76 {}
N 55738 76 55738 -6388 {}
C {devices/opin.sym} -300 -628 0 0 {name=op1 lab=PLL_CLK}
C {devices/ipin.sym} -300 -6492 0 0 {name=ip2 lab=VDD}
C {devices/ipin.sym} -300 2844 0 0 {name=ip3 lab=VSS}
C {devices/ipin.sym} -300 2740 0 0 {name=ip4 lab=CK_DIV40}
N 4 -116 556 -116 {}
N -82 116 8722 116 {}
N -316 2844 55834 2844 {lab=VSS}
N -316 -6492 56440 -6492 {lab=VDD}
N 408 -180 960 -180 {}
N 812 -244 1364 -244 {}
N 1216 -308 6212 -308 {}
N 1620 -372 1904 -372 {}
N 1822 -436 2106 -436 {}
N 1736 180 6298 180 {}
N 1990 244 3384 244 {}
N 1938 308 7222 308 {}
N 2832 -500 3116 -500 {}
N 3034 -564 3234 -564 {}
N -316 -628 4798 -628 {}
N 4044 -692 4328 -692 {}
N 4246 -756 4530 -756 {}
N 4414 372 8434 372 {}
N 5256 -820 5540 -820 {}
N 5458 -884 5658 -884 {}
N 6468 -948 6752 -948 {}
N 6670 -1012 6954 -1012 {}
N 6838 436 13686 436 {}
N 7680 -1076 7964 -1076 {}
N 7882 -1140 8082 -1140 {}
N 8892 -1204 9444 -1204 {}
N 8806 500 17610 500 {}
N 9296 -1268 9848 -1268 {}
N 9700 -1332 10252 -1332 {}
N 10104 -1396 15100 -1396 {}
N 10508 -1460 10792 -1460 {}
N 10710 -1524 10994 -1524 {}
N 10624 564 15186 564 {}
N 10878 628 12272 628 {}
N 10826 692 16110 692 {}
N 11720 -1588 12004 -1588 {}
N 11922 -1652 12122 -1652 {}
N 12932 -1716 13216 -1716 {}
N 13134 -1780 13418 -1780 {}
N 13302 756 17322 756 {}
N 14144 -1844 14428 -1844 {}
N 14346 -1908 14546 -1908 {}
N 15356 -1972 15640 -1972 {}
N 15558 -2036 15842 -2036 {}
N 15726 820 43582 820 {}
N 16568 -2100 16852 -2100 {}
N 16770 -2164 16970 -2164 {}
N 17780 -2228 18064 -2228 {}
N 17694 884 32962 884 {}
N 17982 -2292 18266 -2292 {}
N 17896 948 47506 948 {}
N 18150 1012 19140 1012 {}
N 18992 -2356 30452 -2356 {}
N 19396 -2420 19680 -2420 {}
N 19310 1076 32472 1076 {}
N 19598 -2484 19882 -2484 {}
N 19512 1140 39744 1140 {}
N 19766 1204 20756 1204 {}
N 20608 -2548 44996 -2548 {}
N 21012 -2612 21296 -2612 {}
N 21214 -2676 21498 -2676 {}
N 21382 1268 24190 1268 {}
N 22224 -2740 22508 -2740 {}
N 22426 -2804 22710 -2804 {}
N 22594 1332 25200 1332 {}
N 23436 -2868 23720 -2868 {}
N 23638 -2932 23922 -2932 {}
N 23806 1396 25402 1396 {}
N 24648 -2996 24932 -2996 {}
N 24850 -3060 25134 -3060 {}
N 25018 1460 37724 1460 {}
N 25860 -3124 26144 -3124 {}
N 26062 -3188 26346 -3188 {}
N 25976 1524 30538 1524 {}
N 26230 1588 27624 1588 {}
N 26178 1652 31462 1652 {}
N 27072 -3252 27356 -3252 {}
N 27274 -3316 27474 -3316 {}
N 28284 -3380 28568 -3380 {}
N 28486 -3444 28770 -3444 {}
N 28654 1716 32674 1716 {}
N 29496 -3508 29780 -3508 {}
N 29698 -3572 29898 -3572 {}
N 30708 -3636 30992 -3636 {}
N 30910 -3700 31110 -3700 {}
N 31920 -3764 32204 -3764 {}
N 32122 -3828 32322 -3828 {}
N 33132 -3892 33416 -3892 {}
N 33334 -3956 33618 -3956 {}
N 33248 1780 37810 1780 {}
N 33502 1844 34896 1844 {}
N 33450 1908 38734 1908 {}
N 34344 -4020 34628 -4020 {}
N 34546 -4084 34746 -4084 {}
N 35556 -4148 35840 -4148 {}
N 35758 -4212 36042 -4212 {}
N 35926 1972 39946 1972 {}
N 36768 -4276 37052 -4276 {}
N 36970 -4340 37170 -4340 {}
N 37980 -4404 38264 -4404 {}
N 38182 -4468 38382 -4468 {}
N 38298 2036 40234 2036 {}
N 39192 -4532 39476 -4532 {}
N 39394 -4596 39594 -4596 {}
N 40404 -4660 40688 -4660 {}
N 40606 -4724 40890 -4724 {}
N 40520 2100 45082 2100 {}
N 40774 2164 42168 2164 {}
N 40722 2228 46006 2228 {}
N 41616 -4788 41900 -4788 {}
N 41818 -4852 42018 -4852 {}
N 42828 -4916 43112 -4916 {}
N 43030 -4980 43314 -4980 {}
N 43198 2292 47218 2292 {}
N 44040 -5044 44324 -5044 {}
N 44242 -5108 44442 -5108 {}
N 45252 -5172 45536 -5172 {}
N 45454 -5236 45738 -5236 {}
N 45622 2356 52470 2356 {}
N 46464 -5300 46748 -5300 {}
N 46666 -5364 46866 -5364 {}
N 47676 -5428 48228 -5428 {}
N 47590 2420 56394 2420 {}
N 48080 -5492 48632 -5492 {}
N 48484 -5556 49036 -5556 {}
N 48888 -5620 53884 -5620 {}
N 49292 -5684 49576 -5684 {}
N 49494 -5748 49778 -5748 {}
N 49408 2484 53970 2484 {}
N 49662 2548 51056 2548 {}
N 49610 2612 54894 2612 {}
N 50504 -5812 50788 -5812 {}
N 50706 -5876 50906 -5876 {}
N 51716 -5940 52000 -5940 {}
N 51918 -6004 52202 -6004 {}
N 52086 2676 56106 2676 {}
N 52928 -6068 53212 -6068 {}
N 53130 -6132 53330 -6132 {}
N 54140 -6196 54424 -6196 {}
N 54342 -6260 54626 -6260 {}
N -316 2740 55904 2740 {}
N 55352 -6324 55636 -6324 {}
N 55554 -6388 55754 -6388 {}
